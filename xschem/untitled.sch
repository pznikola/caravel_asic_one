v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {vco_wo_ind.sym} 40 -30 0 0 {}

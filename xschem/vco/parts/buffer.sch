v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 720 -880 720 -820 {
lab=OUT_N}
N 1120 -870 1120 -820 {
lab=OUT_P}
N 720 -990 720 -940 {
lab=VDD}
N 720 -990 1120 -990 {
lab=VDD}
N 1120 -990 1120 -930 {
lab=VDD}
N 920 -1020 920 -990 {
lab=VDD}
N 1170 -770 1280 -770 {
lab=IN_N}
N 590 -770 670 -770 {
lab=IN_P}
N 1120 -840 1310 -840 {
lab=OUT_P}
N 490 -850 720 -850 {
lab=OUT_N}
N 1310 -840 1370 -840 {
lab=OUT_P}
N 920 -720 920 -690 {
lab=BUF_BIAS}
N 920 -690 920 -660 {
lab=BUF_BIAS}
N 1690 -730 1690 -680 {
lab=GND}
N 1740 -730 1740 -680 {
lab=GND}
N 1640 -780 1690 -780 {
lab=GND}
N 1640 -780 1640 -680 {
lab=GND}
N 1690 -680 1690 -650 {
lab=GND}
N 1640 -680 1640 -670 {
lab=GND}
N 1640 -670 1690 -670 {
lab=GND}
N 1740 -680 1740 -660 {
lab=GND}
N 1690 -660 1740 -660 {
lab=GND}
N 1690 -650 1690 -640 {
lab=GND}
N 1810 -730 1810 -680 {
lab=GND}
N 1860 -730 1860 -680 {
lab=GND}
N 1760 -780 1810 -780 {
lab=GND}
N 1760 -780 1760 -680 {
lab=GND}
N 1810 -680 1810 -650 {
lab=GND}
N 1760 -680 1760 -670 {
lab=GND}
N 1760 -670 1810 -670 {
lab=GND}
N 1860 -680 1860 -660 {
lab=GND}
N 1810 -660 1860 -660 {
lab=GND}
N 1810 -650 1810 -640 {
lab=GND}
N 1930 -730 1930 -680 {
lab=GND}
N 1980 -730 1980 -680 {
lab=GND}
N 1880 -780 1930 -780 {
lab=GND}
N 1880 -780 1880 -680 {
lab=GND}
N 1930 -680 1930 -650 {
lab=GND}
N 1880 -680 1880 -670 {
lab=GND}
N 1880 -670 1930 -670 {
lab=GND}
N 1980 -680 1980 -660 {
lab=GND}
N 1930 -660 1980 -660 {
lab=GND}
N 1930 -650 1930 -640 {
lab=GND}
N 2050 -730 2050 -680 {
lab=GND}
N 2100 -730 2100 -680 {
lab=GND}
N 2000 -780 2050 -780 {
lab=GND}
N 2000 -780 2000 -680 {
lab=GND}
N 2050 -680 2050 -650 {
lab=GND}
N 2000 -680 2000 -670 {
lab=GND}
N 2000 -670 2050 -670 {
lab=GND}
N 2100 -680 2100 -660 {
lab=GND}
N 2050 -660 2100 -660 {
lab=GND}
N 2050 -650 2050 -640 {
lab=GND}
N 2170 -730 2170 -680 {
lab=GND}
N 2220 -730 2220 -680 {
lab=GND}
N 2120 -780 2170 -780 {
lab=GND}
N 2120 -780 2120 -680 {
lab=GND}
N 2170 -680 2170 -650 {
lab=GND}
N 2120 -680 2120 -670 {
lab=GND}
N 2120 -670 2170 -670 {
lab=GND}
N 2220 -680 2220 -660 {
lab=GND}
N 2170 -660 2220 -660 {
lab=GND}
N 2170 -650 2170 -640 {
lab=GND}
N 1710 -940 1710 -890 {
lab=GND}
N 1760 -940 1760 -890 {
lab=GND}
N 1660 -990 1710 -990 {
lab=GND}
N 1660 -990 1660 -890 {
lab=GND}
N 1710 -890 1710 -860 {
lab=GND}
N 1660 -890 1660 -880 {
lab=GND}
N 1660 -880 1710 -880 {
lab=GND}
N 1760 -890 1760 -870 {
lab=GND}
N 1710 -870 1760 -870 {
lab=GND}
N 1710 -860 1710 -850 {
lab=GND}
N 1840 -940 1840 -890 {
lab=GND}
N 1890 -940 1890 -890 {
lab=GND}
N 1790 -990 1840 -990 {
lab=GND}
N 1790 -990 1790 -890 {
lab=GND}
N 1840 -890 1840 -860 {
lab=GND}
N 1790 -890 1790 -880 {
lab=GND}
N 1790 -880 1840 -880 {
lab=GND}
N 1890 -890 1890 -870 {
lab=GND}
N 1840 -870 1890 -870 {
lab=GND}
N 1840 -860 1840 -850 {
lab=GND}
N 1960 -940 1960 -890 {
lab=GND}
N 2010 -940 2010 -890 {
lab=GND}
N 1910 -990 1960 -990 {
lab=GND}
N 1910 -990 1910 -890 {
lab=GND}
N 1960 -890 1960 -860 {
lab=GND}
N 1910 -890 1910 -880 {
lab=GND}
N 1910 -880 1960 -880 {
lab=GND}
N 2010 -890 2010 -870 {
lab=GND}
N 1960 -870 2010 -870 {
lab=GND}
N 1960 -860 1960 -850 {
lab=GND}
N 2080 -940 2080 -890 {
lab=GND}
N 2130 -940 2130 -890 {
lab=GND}
N 2030 -990 2080 -990 {
lab=GND}
N 2030 -990 2030 -890 {
lab=GND}
N 2080 -890 2080 -860 {
lab=GND}
N 2030 -890 2030 -880 {
lab=GND}
N 2030 -880 2080 -880 {
lab=GND}
N 2130 -890 2130 -870 {
lab=GND}
N 2080 -870 2130 -870 {
lab=GND}
N 2080 -860 2080 -850 {
lab=GND}
N 720 -770 1120 -770 {
lab=BUF_BIAS}
N 920 -850 920 -770 {
lab=BUF_BIAS}
N 720 -720 1120 -720 {
lab=BUF_BIAS}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 650 -700 0 0 {name=X12[1:0]}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 1190 -700 0 1 {name=X13[1:0]}
C {devices/iopin.sym} 920 -1020 3 0 {name=p2 lab=VDD}
C {devices/iopin.sym} 920 -660 1 0 {name=p3 lab=BUF_BIAS}
C {devices/opin.sym} 1370 -840 0 0 {name=p4 lab=OUT_P}
C {devices/opin.sym} 490 -850 2 0 {name=p5 lab=OUT_N}
C {devices/ipin.sym} 590 -770 0 0 {name=p6 lab=IN_P}
C {devices/ipin.sym} 1280 -770 2 0 {name=p7 lab=IN_N}
C {sky130_fd_pr/res_generic_po.sym} 720 -910 0 0 {name=R1
W=3.5
L=3.5
model=res_generic_po
mult=1}
C {sky130_fd_pr/res_generic_po.sym} 1120 -900 0 0 {name=R2
W=3.5
L=3.5
model=res_generic_po
mult=1}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 1760 -660 0 1 {name=X14}
C {devices/lab_pin.sym} 1690 -640 3 0 {name=l3 sig_type=std_logic lab=GND}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 1880 -660 0 1 {name=X15}
C {devices/lab_pin.sym} 1810 -640 3 0 {name=l6 sig_type=std_logic lab=GND}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 2000 -660 0 1 {name=X16}
C {devices/lab_pin.sym} 1930 -640 3 0 {name=l9 sig_type=std_logic lab=GND}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 2120 -660 0 1 {name=X17}
C {devices/lab_pin.sym} 2050 -640 3 0 {name=l12 sig_type=std_logic lab=GND}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 2240 -660 0 1 {name=X18}
C {devices/lab_pin.sym} 2170 -640 3 0 {name=l15 sig_type=std_logic lab=GND}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 1780 -870 0 1 {name=X19}
C {devices/lab_pin.sym} 1710 -850 3 0 {name=l18 sig_type=std_logic lab=GND}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 1910 -870 0 1 {name=X20}
C {devices/lab_pin.sym} 1840 -850 3 0 {name=l21 sig_type=std_logic lab=GND}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 2030 -870 0 1 {name=X21}
C {devices/lab_pin.sym} 1960 -850 3 0 {name=l24 sig_type=std_logic lab=GND}
C {rf_nfet_01v8_lvt_aM04W5p00L0p15.sym} 2150 -870 0 1 {name=X22}
C {devices/lab_pin.sym} 2080 -850 3 0 {name=l25 sig_type=std_logic lab=GND}
C {devices/iopin.sym} 920 -840 3 0 {name=p1 lab=GND}

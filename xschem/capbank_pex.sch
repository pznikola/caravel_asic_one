** sch_path: xschem/capbank_pex.sch
**.subckt capbank_pex VDD GND bit0 bit1 bit2 bit3 bit4 bit5 OUT_P OUT_N
*.iopin VDD
*.iopin GND
*.ipin bit0
*.ipin bit1
*.ipin bit2
*.ipin bit3
*.ipin bit4
*.ipin bit5
*.iopin OUT_P
*.iopin OUT_N
**** begin user architecture code


X0 OUT_P.t0 a_12666_7846.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X1 a_5456_13412.t2 bit2.t0 a_5166_13336.t1 GND.t209 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X2 OUT_P.t1 a_1416_4186.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X3 OUT_N.t0 a_1706_15242.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X4 a_12956_602.t2 bit5.t0 a_12666_526.t3 GND.t58 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X5 a_1706_13412.t2 a_n456_12816.t8 GND.t241 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X6 a_1706_17072.t2 a_n456_16476.t3 GND.t262 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X7 OUT_N.t1 a_24206_602.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X8 OUT_P.t2 a_1416_9676.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X9 OUT_P.t3 a_12666_6016.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X10 OUT_N.t2 a_12956_602.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X11 a_16706_4262.t3 a_n456_6.t65 GND.t263 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X12 a_8916_7846.t3 a_n456_7326.t32 GND.t240 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X13 a_1706_13412.t0 bit2.t1 a_1416_13336.t2 GND.t208 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X14 OUT_N.t3 a_20456_4262.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X15 a_1706_7922.t3 bit4.t0 a_1416_7846.t3 GND.t24 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X16 a_23916_7846.t3 bit4.t1 a_24206_7922.t3 GND.t25 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X17 a_1416_11506.t3 bit3.t0 a_1706_11582.t1 GND.t6 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X18 a_24206_602.t2 bit5.t1 a_23916_526.t3 GND.t59 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X19 a_5456_15242.t2 a_n456_14646.t5 GND.t192 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X20 a_1416_15166.t3 bit1.t0 a_1706_15242.t1 GND.t5 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X21 a_24206_11582.t0 a_n456_10986.t5 GND.t193 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X22 a_12666_11506.t3 a_n456_10986.t17 GND.t257 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X23 OUT_N.t4 a_20456_9752.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X24 OUT_P.t4 a_12666_13336.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X25 a_24206_4262.t0 a_n456_6.t61 GND.t258 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X26 OUT_P.t5 a_27666_2356.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X27 GND.t184 bit0.t0 a_n456_16476.t0 GND.t183 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.5e+06u l=150000u
X28 OUT_N.t5 a_5456_602.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X29 a_27666_2356.t3 bit5.t2 a_27956_2432.t2 GND.t60 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X30 a_12666_2356.t1 a_n456_6.t39 GND.t210 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X31 OUT_P.t6 a_20166_526.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X32 a_16416_4186.t1 a_n456_6.t40 GND.t211 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X33 a_1706_4262.t2 bit5.t3 a_1416_4186.t0 GND.t61 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X34 a_16416_2356.t3 bit5.t4 a_16706_2432.t2 GND.t62 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X35 a_23916_4186.t3 bit5.t5 a_24206_4262.t2 GND.t63 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X36 a_20166_7846.t1 a_n456_7326.t22 GND.t194 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X37 a_12666_6016.t1 a_n456_6.t35 GND.t195 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X38 a_12956_11582.t1 bit3.t1 a_12666_11506.t2 GND.t7 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X39 OUT_P.t7 a_27666_7846.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X40 a_20456_11582.t2 a_n456_10986.t8 GND.t212 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X41 OUT_N.t6 a_12956_13412.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X42 OUT_N.t7 a_9206_13412.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X43 OUT_P.t8 a_23916_2356.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X44 a_8916_526.t3 bit5.t6 a_9206_602.t2 GND.t64 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X45 a_5166_13336.t3 a_n456_12816.t5 GND.t213 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X46 OUT_P.t9 a_27666_526.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X47 a_16706_9752.t3 bit4.t2 a_16416_9676.t3 GND.t26 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X48 a_23916_4186.t1 a_n456_6.t36 GND.t196 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X49 a_5456_7922.t0 a_n456_7326.t23 GND.t197 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X50 a_5166_2356.t1 a_n456_6.t37 GND.t198 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X51 a_8916_2356.t3 bit5.t7 a_9206_2432.t2 GND.t65 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X52 OUT_P.t10 a_23916_7846.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X53 OUT_P.t11 a_27666_6016.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X54 a_20166_526.t3 bit5.t8 a_20456_602.t2 GND.t66 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X55 a_1706_602.t0 a_n456_6.t38 GND.t199 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X56 a_5166_6016.t1 a_n456_6.t62 GND.t259 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X57 OUT_P.t12 a_1416_526.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X58 a_1416_13336.t3 a_n456_12816.t9 GND.t260 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X59 a_12666_7846.t0 bit4.t3 a_12956_7922.t3 GND.t27 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X60 OUT_N.t8 a_16706_2432.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X61 a_1416_16996.t3 a_n456_16476.t2 GND.t261 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X62 a_27956_2432.t1 bit5.t9 a_27666_2356.t2 GND.t67 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X63 a_20456_602.t1 bit5.t10 a_20166_526.t2 GND.t68 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X64 VDD.t1 bit1.t1 a_n456_14646.t0 VDD.t0 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u
+ l=150000u
X65 OUT_P.t13 a_1416_11506.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X66 a_16706_6092.t2 bit5.t11 a_16416_6016.t3 GND.t69 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X67 a_9206_9752.t3 bit4.t4 a_8916_9676.t3 GND.t28 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X68 a_27666_11506.t3 a_n456_10986.t15 GND.t252 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X69 OUT_P.t14 a_23916_6016.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X70 a_16706_602.t2 bit5.t12 a_16416_526.t3 GND.t70 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X71 OUT_P.t15 a_27666_11506.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X72 a_12956_4262.t0 a_n456_6.t58 GND.t253 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X73 OUT_N.t9 a_16706_7922.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X74 a_20166_526.t1 a_n456_6.t59 GND.t254 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X75 a_20166_7846.t3 bit4.t5 a_20456_7922.t3 GND.t29 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X76 a_12666_4186.t3 bit5.t13 a_12956_4262.t2 GND.t71 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X77 a_27956_11582.t1 bit3.t2 a_27666_11506.t2 GND.t8 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X78 a_16416_526.t1 a_n456_6.t60 GND.t255 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X79 a_23916_11506.t3 a_n456_10986.t16 GND.t256 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X80 a_20166_9676.t1 a_n456_7326.t18 GND.t185 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X81 a_9206_6092.t2 bit5.t14 a_8916_6016.t3 GND.t72 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X82 OUT_N.t10 a_27956_11582.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X83 OUT_N.t11 a_24206_11582.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X84 OUT_N.t12 a_16706_6092.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X85 a_20456_4262.t0 a_n456_6.t32 GND.t186 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X86 a_9206_9752.t0 a_n456_7326.t19 GND.t187 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X87 a_1706_2432.t0 a_n456_6.t33 GND.t188 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X88 OUT_N.t13 a_1706_602.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X89 OUT_P.t16 a_1416_15166.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X90 OUT_P.t17 a_16416_526.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X91 a_12956_7922.t2 bit4.t6 a_12666_7846.t1 GND.t30 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X92 a_1706_6092.t0 a_n456_6.t34 GND.t189 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X93 a_24206_11582.t2 bit3.t3 a_23916_11506.t2 GND.t9 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X94 a_12666_13336.t3 bit2.t2 a_12956_13412.t2 GND.t207 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X95 a_20166_4186.t3 bit5.t15 a_20456_4262.t2 GND.t73 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X96 a_1416_7846.t2 bit4.t7 a_1706_7922.t2 GND.t31 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X97 a_5456_9752.t0 a_n456_7326.t20 GND.t190 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X98 OUT_P.t18 a_8916_11506.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X99 a_27666_7846.t1 a_n456_7326.t21 GND.t191 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X100 VDD.t11 bit4.t8 a_n456_7326.t0 VDD.t10 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u
+ l=150000u
X101 OUT_P.t19 a_23916_526.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X102 a_20456_7922.t2 bit4.t9 a_20166_7846.t2 GND.t32 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X103 a_16706_11582.t2 a_n456_10986.t13 GND.t242 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X104 a_1416_2356.t1 a_n456_6.t53 GND.t243 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X105 a_12956_4262.t1 bit5.t16 a_12666_4186.t2 GND.t74 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X106 OUT_N.t14 a_5456_2432.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X107 OUT_P.t20 a_20166_2356.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X108 a_5166_2356.t3 bit5.t17 a_5456_2432.t2 GND.t75 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X109 OUT_N.t15 a_9206_4262.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X110 OUT_P.t21 a_20166_11506.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X111 a_1416_6016.t1 a_n456_6.t54 GND.t244 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X112 a_1416_4186.t1 bit5.t18 a_1706_4262.t1 GND.t76 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X113 OUT_N.t16 a_5456_7922.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X114 a_12666_526.t1 a_n456_6.t55 GND.t245 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X115 OUT_P.t22 a_20166_7846.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X116 a_24206_2432.t2 bit5.t19 a_23916_2356.t3 GND.t77 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X117 a_12956_11582.t2 a_n456_10986.t14 GND.t246 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X118 OUT_N.t17 a_9206_9752.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X119 a_1706_17072.t0 bit0.t1 a_1416_16996.t2 GND.t250 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X120 OUT_N.t18 a_1706_2432.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X121 a_20456_4262.t1 bit5.t20 a_20166_4186.t2 GND.t78 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X122 a_16706_7922.t0 a_n456_7326.t33 GND.t247 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X123 OUT_P.t23 a_16416_2356.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X124 a_5456_602.t0 a_n456_6.t56 GND.t248 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X125 a_27666_9676.t3 bit4.t10 a_27956_9752.t2 GND.t33 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X126 a_16416_9676.t2 bit4.t11 a_16706_9752.t2 GND.t34 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X127 a_27956_2432.t0 a_n456_6.t57 GND.t249 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X128 OUT_N.t19 a_1706_7922.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X129 OUT_N.t20 a_5456_6092.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X130 OUT_P.t24 a_16416_7846.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X131 OUT_P.t25 a_20166_6016.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X132 a_9206_13412.t0 bit2.t3 a_8916_13336.t3 GND.t206 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X133 a_27956_6092.t0 a_n456_6.t41 GND.t214 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X134 OUT_P.t26 a_8916_4186.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X135 a_24206_7922.t0 a_n456_7326.t24 GND.t215 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X136 a_8916_9676.t1 a_n456_7326.t25 GND.t216 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X137 a_23916_526.t1 a_n456_6.t42 GND.t217 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X138 a_5456_2432.t1 bit5.t21 a_5166_2356.t2 GND.t79 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X139 a_27666_6016.t3 bit5.t22 a_27956_6092.t2 GND.t80 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X140 a_8916_11506.t3 bit3.t4 a_9206_11582.t2 GND.t10 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X141 a_16416_7846.t1 a_n456_7326.t26 GND.t218 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X142 a_16416_6016.t2 bit5.t23 a_16706_6092.t1 GND.t81 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X143 a_8916_9676.t2 bit4.t12 a_9206_9752.t2 GND.t35 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X144 OUT_N.t21 a_1706_6092.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X145 OUT_N.t22 a_12956_4262.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X146 OUT_P.t27 a_8916_9676.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X147 OUT_P.t28 a_16416_6016.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X148 OUT_P.t29 a_5166_11506.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X149 OUT_N.t23 a_24206_4262.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X150 a_9206_2432.t0 a_n456_6.t43 GND.t219 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X151 a_5166_11506.t2 bit3.t5 a_5456_11582.t2 GND.t11 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X152 a_27956_9752.t3 bit4.t13 a_27666_9676.t2 GND.t36 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X153 a_9206_6092.t0 a_n456_6.t44 GND.t220 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X154 OUT_N.t24 a_12956_9752.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X155 a_23916_7846.t1 a_n456_7326.t27 GND.t221 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X156 a_5166_15166.t3 bit1.t2 a_5456_15242.t0 GND.t0 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X157 a_27956_11582.t2 a_n456_10986.t9 GND.t222 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X158 a_16416_11506.t3 a_n456_10986.t10 GND.t223 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X159 OUT_N.t25 a_24206_9752.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X160 a_8916_6016.t2 bit5.t24 a_9206_6092.t1 GND.t82 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X161 OUT_N.t26 a_5456_11582.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X162 a_9206_602.t1 bit5.t25 a_8916_526.t2 GND.t83 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X163 a_1706_11582.t2 a_n456_10986.t11 GND.t224 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X164 OUT_P.t30 a_5166_2356.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X165 a_8916_2356.t1 a_n456_6.t45 GND.t225 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X166 a_27956_6092.t1 bit5.t26 a_27666_6016.t2 GND.t84 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X167 OUT_P.t31 a_5166_15166.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X168 a_9206_13412.t2 a_n456_12816.t6 GND.t226 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X169 OUT_N.t27 a_20456_602.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X170 a_8916_6016.t1 a_n456_6.t46 GND.t227 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X171 a_12956_7922.t0 a_n456_7326.t28 GND.t228 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X172 OUT_P.t32 a_5166_7846.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X173 OUT_N.t28 a_27956_4262.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X174 OUT_N.t29 a_5456_15242.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X175 a_5456_13412.t3 a_n456_12816.t7 GND.t229 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X176 a_1416_13336.t1 bit2.t4 a_1706_13412.t1 GND.t205 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X177 GND.t13 bit3.t6 a_n456_10986.t6 GND.t12 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.5e+06u l=150000u
X178 GND.t2 bit1.t3 a_n456_14646.t1 GND.t1 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.5e+06u l=150000u
X179 OUT_P.t33 a_5166_6016.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X180 a_20456_7922.t0 a_n456_7326.t29 GND.t230 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X181 a_20166_2356.t1 a_n456_6.t47 GND.t231 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X182 OUT_N.t30 a_27956_9752.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X183 a_16706_602.t0 a_n456_6.t48 GND.t232 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X184 a_1706_2432.t1 bit5.t27 a_1416_2356.t3 GND.t85 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X185 a_5166_526.t3 bit5.t28 a_5456_602.t2 GND.t86 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X186 a_23916_2356.t2 bit5.t29 a_24206_2432.t1 GND.t87 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X187 a_12666_4186.t1 a_n456_6.t49 GND.t233 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X188 a_20166_6016.t1 a_n456_6.t50 GND.t234 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X189 a_5166_9676.t3 bit4.t14 a_5456_9752.t3 GND.t37 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X190 a_12956_13412.t1 bit2.t5 a_12666_13336.t2 GND.t204 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X191 a_5166_11506.t3 a_n456_10986.t12 GND.t235 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X192 OUT_P.t34 a_12666_4186.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X193 a_5456_602.t1 bit5.t30 a_5166_526.t2 GND.t88 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X194 a_5456_2432.t0 a_n456_6.t51 GND.t236 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X195 VDD.t5 bit0.t2 a_n456_16476.t1 VDD.t4 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u
+ l=150000u
X196 a_24206_9752.t0 a_n456_7326.t30 GND.t237 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X197 a_12666_9676.t1 a_n456_7326.t31 GND.t238 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X198 a_16706_7922.t3 bit4.t15 a_16416_7846.t3 GND.t38 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X199 a_24206_9752.t3 bit4.t16 a_23916_9676.t3 GND.t39 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X200 a_5456_6092.t0 a_n456_6.t52 GND.t239 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X201 a_5166_526.t0 a_n456_6.t0 GND.t124 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X202 OUT_P.t35 a_1416_2356.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X203 OUT_N.t31 a_9206_602.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X204 OUT_N.t32 a_1706_13412.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X205 a_5166_4186.t0 a_n456_6.t1 GND.t125 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X206 OUT_P.t36 a_12666_9676.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X207 a_27956_602.t0 a_n456_6.t2 GND.t126 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X208 a_5166_6016.t3 bit5.t31 a_5456_6092.t2 GND.t89 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X209 OUT_N.t33 a_1706_17072.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X210 a_16706_11582.t1 bit3.t7 a_16416_11506.t2 GND.t14 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X211 a_1416_11506.t0 a_n456_10986.t0 GND.t127 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X212 OUT_P.t37 a_12666_11506.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X213 a_20456_9752.t0 a_n456_7326.t2 GND.t128 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X214 VDD.t3 bit2.t6 a_n456_12816.t4 VDD.t2 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u
+ l=150000u
X215 a_8916_13336.t0 a_n456_12816.t0 GND.t129 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X216 OUT_P.t38 a_1416_7846.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X217 a_16706_4262.t0 bit5.t32 a_16416_4186.t3 GND.t90 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X218 a_24206_6092.t2 bit5.t33 a_23916_6016.t3 GND.t91 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X219 a_9206_7922.t3 bit4.t17 a_8916_7846.t0 GND.t40 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X220 a_5456_9752.t2 bit4.t18 a_5166_9676.t2 GND.t41 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X221 OUT_N.t34 a_20456_2432.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X222 OUT_N.t35 a_12956_11582.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X223 OUT_N.t36 a_9206_11582.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X224 a_1416_526.t3 bit5.t34 a_1706_602.t2 GND.t92 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X225 a_12666_2356.t3 bit5.t35 a_12956_2432.t2 GND.t93 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X226 OUT_N.t37 a_27956_602.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X227 OUT_P.t39 a_1416_6016.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X228 OUT_N.t38 a_20456_7922.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X229 a_9206_4262.t2 bit5.t36 a_8916_4186.t3 GND.t94 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X230 OUT_P.t40 a_27666_4186.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X231 a_5456_6092.t1 bit5.t37 a_5166_6016.t2 GND.t95 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X232 a_27666_9676.t0 a_n456_7326.t3 GND.t130 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X233 a_1706_4262.t0 a_n456_6.t3 GND.t131 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X234 a_20166_2356.t3 bit5.t38 a_20456_2432.t2 GND.t96 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X235 OUT_P.t41 a_12666_526.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X236 GND.t43 bit4.t19 a_n456_7326.t1 GND.t42 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.5e+06u l=150000u
X237 OUT_N.t39 a_20456_6092.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X238 OUT_P.t42 a_27666_9676.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X239 GND.t98 bit5.t39 a_n456_6.t63 GND.t97 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.5e+06u l=150000u
X240 a_24206_602.t0 a_n456_6.t4 GND.t132 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X241 a_27666_2356.t0 a_n456_6.t5 GND.t133 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X242 OUT_P.t43 a_23916_4186.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X243 a_27666_6016.t0 a_n456_6.t6 GND.t134 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X244 a_23916_9676.t0 a_n456_7326.t4 GND.t135 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X245 a_23916_11506.t1 bit3.t8 a_24206_11582.t1 GND.t15 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X246 a_5456_11582.t1 bit3.t9 a_5166_11506.t1 GND.t16 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X247 a_12956_2432.t1 bit5.t40 a_12666_2356.t2 GND.t99 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X248 OUT_P.t44 a_23916_9676.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X249 a_5456_15242.t1 bit1.t4 a_5166_15166.t2 GND.t3 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X250 OUT_P.t45 a_5166_526.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X251 a_1416_4186.t2 a_n456_6.t7 GND.t136 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X252 a_1416_2356.t2 bit5.t41 a_1706_2432.t2 GND.t100 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X253 a_1706_15242.t2 a_n456_14646.t2 GND.t137 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X254 a_20166_11506.t3 bit3.t10 a_20456_11582.t1 GND.t17 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X255 OUT_N.t40 a_16706_4262.t2 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X256 a_16706_2432.t0 a_n456_6.t8 GND.t138 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X257 a_1706_11582.t0 bit3.t11 a_1416_11506.t2 GND.t18 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X258 OUT_N.t41 a_16706_602.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X259 a_8916_526.t0 a_n456_6.t9 GND.t139 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X260 a_20456_2432.t1 bit5.t42 a_20166_2356.t2 GND.t101 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X261 a_16706_6092.t0 a_n456_6.t10 GND.t140 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X262 a_1706_15242.t0 bit1.t5 a_1416_15166.t2 GND.t4 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X263 a_27666_7846.t3 bit4.t20 a_27956_7922.t3 GND.t44 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X264 a_1706_9752.t3 bit4.t21 a_1416_9676.t0 GND.t45 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X265 OUT_N.t42 a_16706_9752.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X266 a_16416_7846.t2 bit4.t22 a_16706_7922.t2 GND.t46 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X267 a_23916_9676.t2 bit4.t23 a_24206_9752.t2 GND.t47 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X268 a_16706_9752.t0 a_n456_7326.t5 GND.t141 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X269 a_27666_526.t3 bit5.t43 a_27956_602.t2 GND.t102 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X270 a_1416_16996.t1 bit0.t3 a_1706_17072.t1 GND.t251 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X271 a_24206_2432.t0 a_n456_6.t11 GND.t142 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X272 a_27956_4262.t0 a_n456_6.t12 GND.t143 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X273 a_12666_13336.t0 a_n456_12816.t1 GND.t144 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X274 a_24206_6092.t0 a_n456_6.t13 GND.t145 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X275 a_16416_2356.t0 a_n456_6.t14 GND.t146 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X276 a_27956_602.t1 bit5.t44 a_27666_526.t2 GND.t103 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X277 a_27666_4186.t3 bit5.t45 a_27956_4262.t2 GND.t104 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X278 OUT_P.t46 a_1416_13336.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X279 a_12956_9752.t0 a_n456_7326.t6 GND.t147 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X280 VDD.t9 bit5.t46 a_n456_6.t64 VDD.t8 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u
+ l=150000u
X281 a_16416_6016.t0 a_n456_6.t15 GND.t148 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X282 a_16416_4186.t2 bit5.t47 a_16706_4262.t1 GND.t105 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X283 a_23916_6016.t2 bit5.t48 a_24206_6092.t1 GND.t106 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X284 a_1706_6092.t1 bit5.t49 a_1416_6016.t3 GND.t107 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X285 OUT_P.t47 a_1416_16996.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X286 a_8916_7846.t1 bit4.t24 a_9206_7922.t2 GND.t48 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X287 a_8916_13336.t2 bit2.t7 a_9206_13412.t1 GND.t203 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X288 a_12666_7846.t2 a_n456_7326.t7 GND.t149 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X289 a_5166_15166.t0 a_n456_14646.t3 GND.t150 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X290 a_23916_2356.t0 a_n456_6.t16 GND.t151 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X291 a_27956_7922.t2 bit4.t25 a_27666_7846.t2 GND.t49 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X292 a_9206_4262.t0 a_n456_6.t17 GND.t152 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X293 OUT_P.t48 a_23916_11506.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X294 a_23916_6016.t0 a_n456_6.t18 GND.t153 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X295 a_5166_13336.t2 bit2.t8 a_5456_13412.t1 GND.t202 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X296 a_8916_4186.t2 bit5.t50 a_9206_4262.t1 GND.t108 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X297 OUT_N.t43 a_5456_4262.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X298 a_5166_7846.t0 a_n456_7326.t8 GND.t154 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X299 OUT_P.t49 a_20166_4186.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X300 OUT_N.t44 a_9206_2432.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X301 a_1416_15166.t0 a_n456_14646.t4 GND.t155 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X302 a_12666_9676.t3 bit4.t26 a_12956_9752.t3 GND.t50 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X303 a_20166_11506.t0 a_n456_10986.t1 GND.t156 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X304 a_23916_526.t2 bit5.t51 a_24206_602.t1 GND.t109 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X305 a_27956_4262.t1 bit5.t52 a_27666_4186.t2 GND.t110 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X306 a_9206_11582.t0 a_n456_10986.t2 GND.t157 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X307 OUT_N.t45 a_5456_9752.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X308 OUT_N.t46 a_9206_7922.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X309 a_12956_2432.t0 a_n456_6.t19 GND.t158 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X310 OUT_P.t50 a_20166_9676.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X311 a_8916_4186.t0 a_n456_6.t20 GND.t159 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X312 OUT_N.t47 a_1706_4262.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X313 OUT_P.t51 a_8916_13336.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X314 OUT_P.t52 a_16416_4186.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X315 a_12956_6092.t0 a_n456_6.t21 GND.t160 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X316 a_27956_9752.t0 a_n456_7326.t9 GND.t161 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X317 a_16416_9676.t0 a_n456_7326.t10 GND.t162 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X318 a_20166_9676.t3 bit4.t27 a_20456_9752.t3 GND.t51 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X319 a_12666_6016.t3 bit5.t53 a_12956_6092.t2 GND.t111 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X320 a_5456_11582.t0 a_n456_10986.t3 GND.t163 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X321 OUT_N.t48 a_1706_9752.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X322 a_12956_602.t0 a_n456_6.t22 GND.t164 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X323 OUT_P.t53 a_16416_9676.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X324 OUT_N.t49 a_9206_6092.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X325 a_1706_9752.t0 a_n456_7326.t11 GND.t165 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X326 OUT_P.t54 a_8916_2356.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X327 a_20456_2432.t0 a_n456_6.t23 GND.t166 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X328 GND.t201 bit2.t9 a_n456_12816.t3 GND.t200 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.5e+06u l=150000u
X329 a_20456_6092.t0 a_n456_6.t24 GND.t167 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X330 a_12666_11506.t1 bit3.t12 a_12956_11582.t0 GND.t19 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X331 OUT_P.t55 a_16416_11506.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X332 a_1706_602.t1 bit5.t54 a_1416_526.t2 GND.t112 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X333 a_12956_9752.t2 bit4.t28 a_12666_9676.t2 GND.t52 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X334 OUT_N.t50 a_12956_2432.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X335 a_20166_4186.t0 a_n456_6.t25 GND.t168 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X336 a_1706_7922.t0 a_n456_7326.t12 GND.t169 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X337 OUT_P.t56 a_8916_7846.t2 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X338 a_20166_6016.t3 bit5.t55 a_20456_6092.t2 GND.t113 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X339 a_5166_7846.t3 bit4.t29 a_5456_7922.t3 GND.t53 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X340 OUT_N.t51 a_24206_2432.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X341 a_1416_9676.t1 bit4.t30 a_1706_9752.t2 GND.t54 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X342 a_1416_526.t0 a_n456_6.t26 GND.t170 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X343 OUT_N.t52 a_12956_7922.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X344 OUT_N.t53 a_16706_11582.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X345 a_24206_7922.t2 bit4.t31 a_23916_7846.t2 GND.t55 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X346 a_5456_4262.t0 a_n456_6.t27 GND.t171 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X347 OUT_N.t54 a_24206_7922.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X348 OUT_P.t57 a_8916_6016.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X349 a_20456_9752.t2 bit4.t32 a_20166_9676.t2 GND.t56 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X350 a_12956_6092.t1 bit5.t56 a_12666_6016.t2 GND.t114 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X351 a_16416_526.t2 bit5.t57 a_16706_602.t1 GND.t115 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X352 a_5166_4186.t3 bit5.t58 a_5456_4262.t2 GND.t116 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X353 OUT_N.t55 a_20456_11582.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X354 a_1416_7846.t0 a_n456_7326.t13 GND.t172 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X355 a_1416_6016.t2 bit5.t59 a_1706_6092.t2 GND.t117 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X356 OUT_N.t56 a_12956_6092.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X357 OUT_P.t58 a_5166_4186.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X358 VDD.t7 bit3.t13 a_n456_10986.t7 VDD.t6 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u
+ l=150000u
X359 OUT_P.t59 a_5166_13336.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X360 a_8916_11506.t0 a_n456_10986.t4 GND.t173 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X361 OUT_N.t57 a_24206_6092.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X362 a_16706_2432.t1 bit5.t60 a_16416_2356.t2 GND.t118 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X363 a_24206_4262.t1 bit5.t61 a_23916_4186.t2 GND.t119 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X364 a_5166_9676.t0 a_n456_7326.t14 GND.t174 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X365 a_20456_11582.t0 bit3.t14 a_20166_11506.t2 GND.t20 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X366 a_12956_13412.t0 a_n456_12816.t2 GND.t175 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X367 a_20456_6092.t1 bit5.t62 a_20166_6016.t2 GND.t120 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X368 a_16416_11506.t1 bit3.t15 a_16706_11582.t0 GND.t21 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X369 OUT_P.t60 a_8916_526.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X370 a_5456_7922.t2 bit4.t33 a_5166_7846.t2 GND.t57 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X371 a_27666_11506.t1 bit3.t16 a_27956_11582.t0 GND.t22 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X372 OUT_P.t61 a_5166_9676.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X373 a_9206_11582.t1 bit3.t17 a_8916_11506.t2 GND.t23 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p
+ ps=0u w=1.65e+06u l=150000u
X374 OUT_N.t58 a_27956_2432.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X375 OUT_N.t59 a_5456_13412.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X376 a_9206_602.t0 a_n456_6.t28 GND.t176 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X377 a_1416_9676.t2 a_n456_7326.t15 GND.t177 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X378 a_27956_7922.t0 a_n456_7326.t16 GND.t178 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X379 a_9206_2432.t1 bit5.t63 a_8916_2356.t2 GND.t121 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X380 OUT_N.t60 a_27956_7922.t1 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X381 OUT_N.t61 a_1706_11582.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X382 a_5456_4262.t1 bit5.t64 a_5166_4186.t2 GND.t122 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X383 a_20456_602.t0 a_n456_6.t29 GND.t179 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X384 a_27666_526.t0 a_n456_6.t30 GND.t180 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X385 OUT_P.t62 a_12666_2356.t0 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X386 OUT_N.t62 a_27956_6092.t3 sky130_fd_pr__cap_mim_m3_1 l=3.3e+06u w=3.3e+06u
X387 a_12666_526.t2 bit5.t65 a_12956_602.t1 GND.t123 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u
+ w=1.65e+06u l=150000u
X388 a_27666_4186.t0 a_n456_6.t31 GND.t181 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
X389 a_9206_7922.t0 a_n456_7326.t17 GND.t182 sky130_fd_pr__res_xhigh_po_0p35 l=1e+06u
C0 bit2 OUT_P 0.54fF
C1 bit3 OUT_N 0.54fF
C2 VDD bit0 0.12fF
C3 bit3 OUT_P 0.54fF
C4 bit4 OUT_N 1.09fF
C5 VDD bit1 0.12fF
C6 bit5 OUT_N 2.17fF
C7 bit4 OUT_P 1.09fF
C8 VDD bit2 0.12fF
C9 bit5 OUT_P 2.17fF
C10 VDD bit3 0.12fF
C11 OUT_N OUT_P 61.08fF
C12 VDD bit4 0.21fF
C13 VDD bit5 0.21fF
C14 VDD OUT_N 0.14fF
C15 bit0 OUT_N 0.54fF
C16 VDD OUT_P 0.14fF
C17 bit1 OUT_N 0.54fF
C18 bit0 OUT_P 0.54fF
C19 bit2 OUT_N 0.54fF
C20 bit1 OUT_P 0.54fF
R0 OUT_P.n55 OUT_P.n54 4.694
R1 OUT_P.n57 OUT_P.n36 2.932
R2 OUT_P.n56 OUT_P.n42 2.932
R3 OUT_P.n55 OUT_P.n48 2.932
R4 OUT_P.n59 OUT_P.n23 2.072
R5 OUT_P.n58 OUT_P.n30 2.072
R6 OUT_P.n56 OUT_P.n55 1.762
R7 OUT_P.n57 OUT_P.n56 1.762
R8 OUT_P.n58 OUT_P.n57 1.762
R9 OUT_P.n59 OUT_P.n58 1.762
R10 OUT_P.n60 OUT_P.n59 1.762
R11 OUT_P.n61 OUT_P.n60 1.762
R12 OUT_P.n60 OUT_P.n16 1.212
R13 OUT_P.n0 OUT_P.t12 0.964
R14 OUT_P.n9 OUT_P.t45 0.964
R15 OUT_P.n17 OUT_P.t60 0.964
R16 OUT_P.n24 OUT_P.t41 0.964
R17 OUT_P.n31 OUT_P.t17 0.964
R18 OUT_P.n37 OUT_P.t6 0.964
R19 OUT_P.n43 OUT_P.t19 0.964
R20 OUT_P.n49 OUT_P.t9 0.964
R21 OUT_P.n1 OUT_P.n0 0.813
R22 OUT_P.n2 OUT_P.n1 0.813
R23 OUT_P.n3 OUT_P.n2 0.813
R24 OUT_P.n4 OUT_P.n3 0.813
R25 OUT_P.n5 OUT_P.n4 0.813
R26 OUT_P.n6 OUT_P.n5 0.813
R27 OUT_P.n7 OUT_P.n6 0.813
R28 OUT_P.n8 OUT_P.n7 0.813
R29 OUT_P.n10 OUT_P.n9 0.813
R30 OUT_P.n11 OUT_P.n10 0.813
R31 OUT_P.n12 OUT_P.n11 0.813
R32 OUT_P.n13 OUT_P.n12 0.813
R33 OUT_P.n14 OUT_P.n13 0.813
R34 OUT_P.n15 OUT_P.n14 0.813
R35 OUT_P.n16 OUT_P.n15 0.813
R36 OUT_P.n18 OUT_P.n17 0.813
R37 OUT_P.n19 OUT_P.n18 0.813
R38 OUT_P.n20 OUT_P.n19 0.813
R39 OUT_P.n21 OUT_P.n20 0.813
R40 OUT_P.n22 OUT_P.n21 0.813
R41 OUT_P.n23 OUT_P.n22 0.813
R42 OUT_P.n25 OUT_P.n24 0.813
R43 OUT_P.n26 OUT_P.n25 0.813
R44 OUT_P.n27 OUT_P.n26 0.813
R45 OUT_P.n28 OUT_P.n27 0.813
R46 OUT_P.n29 OUT_P.n28 0.813
R47 OUT_P.n30 OUT_P.n29 0.813
R48 OUT_P.n32 OUT_P.n31 0.813
R49 OUT_P.n33 OUT_P.n32 0.813
R50 OUT_P.n34 OUT_P.n33 0.813
R51 OUT_P.n35 OUT_P.n34 0.813
R52 OUT_P.n36 OUT_P.n35 0.813
R53 OUT_P.n38 OUT_P.n37 0.813
R54 OUT_P.n39 OUT_P.n38 0.813
R55 OUT_P.n40 OUT_P.n39 0.813
R56 OUT_P.n41 OUT_P.n40 0.813
R57 OUT_P.n42 OUT_P.n41 0.813
R58 OUT_P.n44 OUT_P.n43 0.813
R59 OUT_P.n45 OUT_P.n44 0.813
R60 OUT_P.n46 OUT_P.n45 0.813
R61 OUT_P.n47 OUT_P.n46 0.813
R62 OUT_P.n48 OUT_P.n47 0.813
R63 OUT_P.n50 OUT_P.n49 0.813
R64 OUT_P.n51 OUT_P.n50 0.813
R65 OUT_P.n52 OUT_P.n51 0.813
R66 OUT_P.n53 OUT_P.n52 0.813
R67 OUT_P.n54 OUT_P.n53 0.813
R68 OUT_P OUT_P.n61 0.69
R69 OUT_P.n61 OUT_P.n8 0.352
R70 OUT_P.n0 OUT_P.t35 0.151
R71 OUT_P.n1 OUT_P.t1 0.151
R72 OUT_P.n2 OUT_P.t39 0.151
R73 OUT_P.n3 OUT_P.t38 0.151
R74 OUT_P.n4 OUT_P.t2 0.151
R75 OUT_P.n5 OUT_P.t13 0.151
R76 OUT_P.n6 OUT_P.t46 0.151
R77 OUT_P.n7 OUT_P.t16 0.151
R78 OUT_P.n8 OUT_P.t47 0.151
R79 OUT_P.n9 OUT_P.t30 0.151
R80 OUT_P.n10 OUT_P.t58 0.151
R81 OUT_P.n11 OUT_P.t33 0.151
R82 OUT_P.n12 OUT_P.t32 0.151
R83 OUT_P.n13 OUT_P.t61 0.151
R84 OUT_P.n14 OUT_P.t29 0.151
R85 OUT_P.n15 OUT_P.t59 0.151
R86 OUT_P.n16 OUT_P.t31 0.151
R87 OUT_P.n17 OUT_P.t54 0.151
R88 OUT_P.n18 OUT_P.t26 0.151
R89 OUT_P.n19 OUT_P.t57 0.151
R90 OUT_P.n20 OUT_P.t56 0.151
R91 OUT_P.n21 OUT_P.t27 0.151
R92 OUT_P.n22 OUT_P.t18 0.151
R93 OUT_P.n23 OUT_P.t51 0.151
R94 OUT_P.n24 OUT_P.t62 0.151
R95 OUT_P.n25 OUT_P.t34 0.151
R96 OUT_P.n26 OUT_P.t3 0.151
R97 OUT_P.n27 OUT_P.t0 0.151
R98 OUT_P.n28 OUT_P.t36 0.151
R99 OUT_P.n29 OUT_P.t37 0.151
R100 OUT_P.n30 OUT_P.t4 0.151
R101 OUT_P.n31 OUT_P.t23 0.151
R102 OUT_P.n32 OUT_P.t52 0.151
R103 OUT_P.n33 OUT_P.t28 0.151
R104 OUT_P.n34 OUT_P.t24 0.151
R105 OUT_P.n35 OUT_P.t53 0.151
R106 OUT_P.n36 OUT_P.t55 0.151
R107 OUT_P.n37 OUT_P.t20 0.151
R108 OUT_P.n38 OUT_P.t49 0.151
R109 OUT_P.n39 OUT_P.t25 0.151
R110 OUT_P.n40 OUT_P.t22 0.151
R111 OUT_P.n41 OUT_P.t50 0.151
R112 OUT_P.n42 OUT_P.t21 0.151
R113 OUT_P.n43 OUT_P.t8 0.151
R114 OUT_P.n44 OUT_P.t43 0.151
R115 OUT_P.n45 OUT_P.t14 0.151
R116 OUT_P.n46 OUT_P.t10 0.151
R117 OUT_P.n47 OUT_P.t44 0.151
R118 OUT_P.n48 OUT_P.t48 0.151
R119 OUT_P.n49 OUT_P.t5 0.151
R120 OUT_P.n50 OUT_P.t40 0.151
R121 OUT_P.n51 OUT_P.t11 0.151
R122 OUT_P.n52 OUT_P.t7 0.151
R123 OUT_P.n53 OUT_P.t42 0.151
R124 OUT_P.n54 OUT_P.t15 0.151
R125 a_12666_7846.n10 a_12666_7846.t1 10.181
R126 a_12666_7846.n10 a_12666_7846.t0 10.181
R127 a_12666_7846.t2 a_12666_7846.n18 9.68
R128 a_12666_7846.n1 a_12666_7846.n0 9.302
R129 a_12666_7846.n7 a_12666_7846.n6 9.3
R130 a_12666_7846.n5 a_12666_7846.n4 9.3
R131 a_12666_7846.n9 a_12666_7846.n8 9
R132 a_12666_7846.n13 a_12666_7846.n12 7.729
R133 a_12666_7846.n13 a_12666_7846.n10 6.296
R134 a_12666_7846.n16 a_12666_7846.n1 4.508
R135 a_12666_7846.n15 a_12666_7846.n14 4.501
R136 a_12666_7846.n15 a_12666_7846.n9 4.501
R137 a_12666_7846.n16 a_12666_7846.n3 4.494
R138 a_12666_7846.n18 a_12666_7846.t3 1.259
R139 a_12666_7846.n12 a_12666_7846.n11 0.536
R140 a_12666_7846.n18 a_12666_7846.n17 0.415
R141 a_12666_7846.n14 a_12666_7846.n13 0.151
R142 a_12666_7846.n7 a_12666_7846.n5 0.028
R143 a_12666_7846.n3 a_12666_7846.n2 0.025
R144 a_12666_7846.n17 a_12666_7846.n16 0.021
R145 a_12666_7846.n9 a_12666_7846.n7 0.012
R146 a_12666_7846.n16 a_12666_7846.n15 0.006
R147 bit2.n0 bit2.t6 552.693
R148 bit2.n5 bit2.t1 300.446
R149 bit2.n3 bit2.t4 300.446
R150 bit2.n11 bit2.t0 300.446
R151 bit2.n9 bit2.t8 300.446
R152 bit2.n19 bit2.t3 300.446
R153 bit2.n17 bit2.t7 300.446
R154 bit2.n27 bit2.t5 300.446
R155 bit2.n25 bit2.t2 300.446
R156 bit2.n0 bit2.t9 279.56
R157 bit2.n8 bit2.n0 122.804
R158 bit2.n4 bit2.n3 27.537
R159 bit2.n14 bit2.n11 27.536
R160 bit2.n22 bit2.n19 27.536
R161 bit2.n30 bit2.n27 27.536
R162 bit2.n6 bit2.n5 24.127
R163 bit2.n10 bit2.n9 24.127
R164 bit2.n18 bit2.n17 24.127
R165 bit2.n26 bit2.n25 24.127
R166 bit2 bit2.n32 23.819
R167 bit2.n2 bit2.n1 8.764
R168 bit2.n13 bit2.n12 8.764
R169 bit2.n21 bit2.n20 8.764
R170 bit2.n29 bit2.n28 8.764
R171 bit2.n16 bit2.n8 4.958
R172 bit2.n24 bit2.n16 4.958
R173 bit2.n32 bit2.n24 4.958
R174 bit2.n15 bit2.n10 4.662
R175 bit2.n23 bit2.n18 4.662
R176 bit2.n31 bit2.n26 4.662
R177 bit2.n7 bit2.n6 4.661
R178 bit2.n14 bit2.n13 3.401
R179 bit2.n22 bit2.n21 3.401
R180 bit2.n30 bit2.n29 3.401
R181 bit2.n4 bit2.n2 3.401
R182 bit2.n7 bit2.n4 0.626
R183 bit2.n15 bit2.n14 0.626
R184 bit2.n23 bit2.n22 0.626
R185 bit2.n31 bit2.n30 0.626
R186 bit2.n8 bit2.n7 0.329
R187 bit2.n16 bit2.n15 0.329
R188 bit2.n24 bit2.n23 0.329
R189 bit2.n32 bit2.n31 0.329
R190 a_5166_13336.n10 a_5166_13336.t1 10.181
R191 a_5166_13336.n10 a_5166_13336.t2 10.181
R192 a_5166_13336.t3 a_5166_13336.n18 9.68
R193 a_5166_13336.n1 a_5166_13336.n0 9.302
R194 a_5166_13336.n7 a_5166_13336.n6 9.3
R195 a_5166_13336.n5 a_5166_13336.n4 9.3
R196 a_5166_13336.n9 a_5166_13336.n8 9
R197 a_5166_13336.n13 a_5166_13336.n12 7.729
R198 a_5166_13336.n13 a_5166_13336.n10 6.296
R199 a_5166_13336.n16 a_5166_13336.n1 4.508
R200 a_5166_13336.n15 a_5166_13336.n14 4.501
R201 a_5166_13336.n15 a_5166_13336.n9 4.501
R202 a_5166_13336.n16 a_5166_13336.n3 4.494
R203 a_5166_13336.n18 a_5166_13336.t0 1.259
R204 a_5166_13336.n12 a_5166_13336.n11 0.536
R205 a_5166_13336.n18 a_5166_13336.n17 0.415
R206 a_5166_13336.n14 a_5166_13336.n13 0.151
R207 a_5166_13336.n7 a_5166_13336.n5 0.028
R208 a_5166_13336.n3 a_5166_13336.n2 0.025
R209 a_5166_13336.n17 a_5166_13336.n16 0.021
R210 a_5166_13336.n9 a_5166_13336.n7 0.012
R211 a_5166_13336.n16 a_5166_13336.n15 0.006
R212 a_5456_13412.n26 a_5456_13412.t2 10.181
R213 a_5456_13412.n18 a_5456_13412.t1 10.181
R214 a_5456_13412.t3 a_5456_13412.n39 9.68
R215 a_5456_13412.n3 a_5456_13412.n2 9.302
R216 a_5456_13412.n13 a_5456_13412.n12 9.302
R217 a_5456_13412.n32 a_5456_13412.n31 9.3
R218 a_5456_13412.n34 a_5456_13412.n33 9.3
R219 a_5456_13412.n7 a_5456_13412.n6 9.3
R220 a_5456_13412.n5 a_5456_13412.n4 9.3
R221 a_5456_13412.n36 a_5456_13412.n35 9
R222 a_5456_13412.n9 a_5456_13412.n8 9
R223 a_5456_13412.n27 a_5456_13412.n25 7.729
R224 a_5456_13412.n19 a_5456_13412.n17 7.729
R225 a_5456_13412.n27 a_5456_13412.n26 6.296
R226 a_5456_13412.n19 a_5456_13412.n18 6.296
R227 a_5456_13412.n30 a_5456_13412.n3 4.508
R228 a_5456_13412.n14 a_5456_13412.n13 4.508
R229 a_5456_13412.n37 a_5456_13412.n36 4.496
R230 a_5456_13412.n21 a_5456_13412.n20 4.496
R231 a_5456_13412.n29 a_5456_13412.n28 4.495
R232 a_5456_13412.n10 a_5456_13412.n9 4.495
R233 a_5456_13412.n14 a_5456_13412.n11 4.494
R234 a_5456_13412.n30 a_5456_13412.n1 4.494
R235 a_5456_13412.n39 a_5456_13412.t0 1.087
R236 a_5456_13412.n25 a_5456_13412.n24 0.536
R237 a_5456_13412.n17 a_5456_13412.n16 0.536
R238 a_5456_13412.n39 a_5456_13412.n38 0.255
R239 a_5456_13412.n28 a_5456_13412.n27 0.151
R240 a_5456_13412.n20 a_5456_13412.n19 0.151
R241 a_5456_13412.n23 a_5456_13412.n22 0.125
R242 a_5456_13412.n34 a_5456_13412.n32 0.028
R243 a_5456_13412.n7 a_5456_13412.n5 0.028
R244 a_5456_13412.n1 a_5456_13412.n0 0.025
R245 a_5456_13412.n20 a_5456_13412.n15 0.024
R246 a_5456_13412.n36 a_5456_13412.n34 0.012
R247 a_5456_13412.n9 a_5456_13412.n7 0.012
R248 a_5456_13412.n29 a_5456_13412.n23 0.011
R249 a_5456_13412.n30 a_5456_13412.n29 0.011
R250 a_5456_13412.n14 a_5456_13412.n10 0.011
R251 a_5456_13412.n38 a_5456_13412.n37 0.01
R252 a_5456_13412.n22 a_5456_13412.n21 0.01
R253 a_5456_13412.n21 a_5456_13412.n14 0.01
R254 a_5456_13412.n37 a_5456_13412.n30 0.01
R255 GND.n6 GND.t183 3941.67
R256 GND.n98 GND.t1 3941.67
R257 GND.n272 GND.t200 3941.67
R258 GND.n610 GND.t12 3941.67
R259 GND.n1276 GND.t42 3941.67
R260 GND.n2598 GND.t97 3941.67
R261 GND.n52 GND.t262 650.171
R262 GND.n44 GND.t261 650.171
R263 GND.n184 GND.t192 650.171
R264 GND.n145 GND.t150 650.171
R265 GND.n225 GND.t137 650.171
R266 GND.n105 GND.t155 650.171
R267 GND.n438 GND.t175 650.171
R268 GND.n399 GND.t144 650.171
R269 GND.n479 GND.t226 650.171
R270 GND.n359 GND.t129 650.171
R271 GND.n521 GND.t229 650.171
R272 GND.n319 GND.t213 650.171
R273 GND.n563 GND.t241 650.171
R274 GND.n279 GND.t260 650.171
R275 GND.n936 GND.t222 650.171
R276 GND.n897 GND.t252 650.171
R277 GND.n977 GND.t193 650.171
R278 GND.n857 GND.t256 650.171
R279 GND.n1019 GND.t212 650.171
R280 GND.n817 GND.t156 650.171
R281 GND.n1061 GND.t242 650.171
R282 GND.n777 GND.t223 650.171
R283 GND.n1103 GND.t246 650.171
R284 GND.n737 GND.t257 650.171
R285 GND.n1145 GND.t157 650.171
R286 GND.n697 GND.t173 650.171
R287 GND.n1187 GND.t163 650.171
R288 GND.n657 GND.t235 650.171
R289 GND.n1229 GND.t224 650.171
R290 GND.n617 GND.t127 650.171
R291 GND.n1883 GND.t165 650.171
R292 GND.n1922 GND.t177 650.171
R293 GND.n1843 GND.t190 650.171
R294 GND.n1963 GND.t174 650.171
R295 GND.n1803 GND.t187 650.171
R296 GND.n2005 GND.t216 650.171
R297 GND.n1763 GND.t147 650.171
R298 GND.n2047 GND.t238 650.171
R299 GND.n1723 GND.t141 650.171
R300 GND.n2089 GND.t162 650.171
R301 GND.n1683 GND.t128 650.171
R302 GND.n2131 GND.t185 650.171
R303 GND.n1643 GND.t237 650.171
R304 GND.n2173 GND.t135 650.171
R305 GND.n1603 GND.t161 650.171
R306 GND.n2215 GND.t130 650.171
R307 GND.n2257 GND.t178 650.171
R308 GND.n1563 GND.t191 650.171
R309 GND.n2299 GND.t215 650.171
R310 GND.n1523 GND.t221 650.171
R311 GND.n2341 GND.t230 650.171
R312 GND.n1483 GND.t194 650.171
R313 GND.n2383 GND.t247 650.171
R314 GND.n1443 GND.t218 650.171
R315 GND.n2425 GND.t228 650.171
R316 GND.n1403 GND.t149 650.171
R317 GND.n2467 GND.t182 650.171
R318 GND.n1363 GND.t240 650.171
R319 GND.n2509 GND.t197 650.171
R320 GND.n1323 GND.t154 650.171
R321 GND.n2551 GND.t169 650.171
R322 GND.n1283 GND.t172 650.171
R323 GND.n3205 GND.t189 650.171
R324 GND.n3244 GND.t244 650.171
R325 GND.n3165 GND.t239 650.171
R326 GND.n3285 GND.t259 650.171
R327 GND.n3125 GND.t220 650.171
R328 GND.n3327 GND.t227 650.171
R329 GND.n3085 GND.t160 650.171
R330 GND.n3369 GND.t195 650.171
R331 GND.n3045 GND.t140 650.171
R332 GND.n3411 GND.t148 650.171
R333 GND.n3005 GND.t167 650.171
R334 GND.n3453 GND.t234 650.171
R335 GND.n2965 GND.t145 650.171
R336 GND.n3495 GND.t153 650.171
R337 GND.n2925 GND.t214 650.171
R338 GND.n3537 GND.t134 650.171
R339 GND.n3860 GND.t131 650.171
R340 GND.n3899 GND.t136 650.171
R341 GND.n3820 GND.t171 650.171
R342 GND.n3940 GND.t125 650.171
R343 GND.n3780 GND.t152 650.171
R344 GND.n3982 GND.t159 650.171
R345 GND.n3740 GND.t253 650.171
R346 GND.n4024 GND.t233 650.171
R347 GND.n3700 GND.t263 650.171
R348 GND.n4066 GND.t211 650.171
R349 GND.n3660 GND.t186 650.171
R350 GND.n4108 GND.t168 650.171
R351 GND.n3620 GND.t258 650.171
R352 GND.n4150 GND.t196 650.171
R353 GND.n3580 GND.t143 650.171
R354 GND.n4192 GND.t181 650.171
R355 GND.n4516 GND.t188 650.171
R356 GND.n4555 GND.t243 650.171
R357 GND.n4476 GND.t236 650.171
R358 GND.n4596 GND.t198 650.171
R359 GND.n4436 GND.t219 650.171
R360 GND.n4638 GND.t225 650.171
R361 GND.n4396 GND.t158 650.171
R362 GND.n4680 GND.t210 650.171
R363 GND.n4356 GND.t138 650.171
R364 GND.n4722 GND.t146 650.171
R365 GND.n4316 GND.t166 650.171
R366 GND.n4764 GND.t231 650.171
R367 GND.n4276 GND.t142 650.171
R368 GND.n4806 GND.t151 650.171
R369 GND.n4236 GND.t249 650.171
R370 GND.n4848 GND.t133 650.171
R371 GND.n4891 GND.t126 650.171
R372 GND.n2885 GND.t180 650.171
R373 GND.n4933 GND.t132 650.171
R374 GND.n2845 GND.t217 650.171
R375 GND.n4975 GND.t179 650.171
R376 GND.n2805 GND.t254 650.171
R377 GND.n5017 GND.t232 650.171
R378 GND.n2765 GND.t255 650.171
R379 GND.n5059 GND.t164 650.171
R380 GND.n2725 GND.t245 650.171
R381 GND.n5101 GND.t176 650.171
R382 GND.n2685 GND.t139 650.171
R383 GND.n5143 GND.t248 650.171
R384 GND.n2645 GND.t124 650.171
R385 GND.n5185 GND.t199 650.171
R386 GND.n2605 GND.t170 650.171
R387 GND.n52 GND.t250 582.13
R388 GND.n44 GND.t251 582.13
R389 GND.n184 GND.t3 582.13
R390 GND.n145 GND.t0 582.13
R391 GND.n225 GND.t4 582.13
R392 GND.n105 GND.t5 582.13
R393 GND.n438 GND.t204 582.13
R394 GND.n399 GND.t207 582.13
R395 GND.n479 GND.t206 582.13
R396 GND.n359 GND.t203 582.13
R397 GND.n521 GND.t209 582.13
R398 GND.n319 GND.t202 582.13
R399 GND.n563 GND.t208 582.13
R400 GND.n279 GND.t205 582.13
R401 GND.n936 GND.t8 582.13
R402 GND.n897 GND.t22 582.13
R403 GND.n977 GND.t9 582.13
R404 GND.n857 GND.t15 582.13
R405 GND.n1019 GND.t20 582.13
R406 GND.n817 GND.t17 582.13
R407 GND.n1061 GND.t14 582.13
R408 GND.n777 GND.t21 582.13
R409 GND.n1103 GND.t7 582.13
R410 GND.n737 GND.t19 582.13
R411 GND.n1145 GND.t23 582.13
R412 GND.n697 GND.t10 582.13
R413 GND.n1187 GND.t16 582.13
R414 GND.n657 GND.t11 582.13
R415 GND.n1229 GND.t18 582.13
R416 GND.n617 GND.t6 582.13
R417 GND.n1883 GND.t45 582.13
R418 GND.n1922 GND.t54 582.13
R419 GND.n1843 GND.t41 582.13
R420 GND.n1963 GND.t37 582.13
R421 GND.n1803 GND.t28 582.13
R422 GND.n2005 GND.t35 582.13
R423 GND.n1763 GND.t52 582.13
R424 GND.n2047 GND.t50 582.13
R425 GND.n1723 GND.t26 582.13
R426 GND.n2089 GND.t34 582.13
R427 GND.n1683 GND.t56 582.13
R428 GND.n2131 GND.t51 582.13
R429 GND.n1643 GND.t39 582.13
R430 GND.n2173 GND.t47 582.13
R431 GND.n1603 GND.t36 582.13
R432 GND.n2215 GND.t33 582.13
R433 GND.n2257 GND.t49 582.13
R434 GND.n1563 GND.t44 582.13
R435 GND.n2299 GND.t55 582.13
R436 GND.n1523 GND.t25 582.13
R437 GND.n2341 GND.t32 582.13
R438 GND.n1483 GND.t29 582.13
R439 GND.n2383 GND.t38 582.13
R440 GND.n1443 GND.t46 582.13
R441 GND.n2425 GND.t30 582.13
R442 GND.n1403 GND.t27 582.13
R443 GND.n2467 GND.t40 582.13
R444 GND.n1363 GND.t48 582.13
R445 GND.n2509 GND.t57 582.13
R446 GND.n1323 GND.t53 582.13
R447 GND.n2551 GND.t24 582.13
R448 GND.n1283 GND.t31 582.13
R449 GND.n3205 GND.t107 582.13
R450 GND.n3244 GND.t117 582.13
R451 GND.n3165 GND.t95 582.13
R452 GND.n3285 GND.t89 582.13
R453 GND.n3125 GND.t72 582.13
R454 GND.n3327 GND.t82 582.13
R455 GND.n3085 GND.t114 582.13
R456 GND.n3369 GND.t111 582.13
R457 GND.n3045 GND.t69 582.13
R458 GND.n3411 GND.t81 582.13
R459 GND.n3005 GND.t120 582.13
R460 GND.n3453 GND.t113 582.13
R461 GND.n2965 GND.t91 582.13
R462 GND.n3495 GND.t106 582.13
R463 GND.n2925 GND.t84 582.13
R464 GND.n3537 GND.t80 582.13
R465 GND.n3860 GND.t61 582.13
R466 GND.n3899 GND.t76 582.13
R467 GND.n3820 GND.t122 582.13
R468 GND.n3940 GND.t116 582.13
R469 GND.n3780 GND.t94 582.13
R470 GND.n3982 GND.t108 582.13
R471 GND.n3740 GND.t74 582.13
R472 GND.n4024 GND.t71 582.13
R473 GND.n3700 GND.t90 582.13
R474 GND.n4066 GND.t105 582.13
R475 GND.n3660 GND.t78 582.13
R476 GND.n4108 GND.t73 582.13
R477 GND.n3620 GND.t119 582.13
R478 GND.n4150 GND.t63 582.13
R479 GND.n3580 GND.t110 582.13
R480 GND.n4192 GND.t104 582.13
R481 GND.n4516 GND.t85 582.13
R482 GND.n4555 GND.t100 582.13
R483 GND.n4476 GND.t79 582.13
R484 GND.n4596 GND.t75 582.13
R485 GND.n4436 GND.t121 582.13
R486 GND.n4638 GND.t65 582.13
R487 GND.n4396 GND.t99 582.13
R488 GND.n4680 GND.t93 582.13
R489 GND.n4356 GND.t118 582.13
R490 GND.n4722 GND.t62 582.13
R491 GND.n4316 GND.t101 582.13
R492 GND.n4764 GND.t96 582.13
R493 GND.n4276 GND.t77 582.13
R494 GND.n4806 GND.t87 582.13
R495 GND.n4236 GND.t67 582.13
R496 GND.n4848 GND.t60 582.13
R497 GND.n4891 GND.t103 582.13
R498 GND.n2885 GND.t102 582.13
R499 GND.n4933 GND.t59 582.13
R500 GND.n2845 GND.t109 582.13
R501 GND.n4975 GND.t68 582.13
R502 GND.n2805 GND.t66 582.13
R503 GND.n5017 GND.t70 582.13
R504 GND.n2765 GND.t115 582.13
R505 GND.n5059 GND.t58 582.13
R506 GND.n2725 GND.t123 582.13
R507 GND.n5101 GND.t83 582.13
R508 GND.n2685 GND.t64 582.13
R509 GND.n5143 GND.t88 582.13
R510 GND.n2645 GND.t86 582.13
R511 GND.n5185 GND.t112 582.13
R512 GND.n2605 GND.t92 582.13
R513 GND.n3 GND.t184 93.671
R514 GND.n95 GND.t2 93.671
R515 GND.n269 GND.t201 93.671
R516 GND.n607 GND.t13 93.671
R517 GND.n1273 GND.t43 93.671
R518 GND.n2595 GND.t98 93.671
R519 GND.n4 GND.n0 73.875
R520 GND.n96 GND.n92 73.875
R521 GND.n270 GND.n266 73.875
R522 GND.n608 GND.n604 73.875
R523 GND.n1274 GND.n1270 73.875
R524 GND.n2596 GND.n2592 73.875
R525 GND.n169 GND.n168 55.353
R526 GND.n129 GND.n128 55.353
R527 GND.n423 GND.n422 55.353
R528 GND.n383 GND.n382 55.353
R529 GND.n343 GND.n342 55.353
R530 GND.n303 GND.n302 55.353
R531 GND.n921 GND.n920 55.353
R532 GND.n881 GND.n880 55.353
R533 GND.n841 GND.n840 55.353
R534 GND.n801 GND.n800 55.353
R535 GND.n761 GND.n760 55.353
R536 GND.n721 GND.n720 55.353
R537 GND.n681 GND.n680 55.353
R538 GND.n641 GND.n640 55.353
R539 GND.n1907 GND.n1906 55.353
R540 GND.n1867 GND.n1866 55.353
R541 GND.n1827 GND.n1826 55.353
R542 GND.n1787 GND.n1786 55.353
R543 GND.n1747 GND.n1746 55.353
R544 GND.n1707 GND.n1706 55.353
R545 GND.n1667 GND.n1666 55.353
R546 GND.n1627 GND.n1626 55.353
R547 GND.n1587 GND.n1586 55.353
R548 GND.n1547 GND.n1546 55.353
R549 GND.n1507 GND.n1506 55.353
R550 GND.n1467 GND.n1466 55.353
R551 GND.n1427 GND.n1426 55.353
R552 GND.n1387 GND.n1386 55.353
R553 GND.n1347 GND.n1346 55.353
R554 GND.n1307 GND.n1306 55.353
R555 GND.n3229 GND.n3228 55.353
R556 GND.n3189 GND.n3188 55.353
R557 GND.n3149 GND.n3148 55.353
R558 GND.n3109 GND.n3108 55.353
R559 GND.n3069 GND.n3068 55.353
R560 GND.n3029 GND.n3028 55.353
R561 GND.n2989 GND.n2988 55.353
R562 GND.n2949 GND.n2948 55.353
R563 GND.n3884 GND.n3883 55.353
R564 GND.n3844 GND.n3843 55.353
R565 GND.n3804 GND.n3803 55.353
R566 GND.n3764 GND.n3763 55.353
R567 GND.n3724 GND.n3723 55.353
R568 GND.n3684 GND.n3683 55.353
R569 GND.n3644 GND.n3643 55.353
R570 GND.n3604 GND.n3603 55.353
R571 GND.n4540 GND.n4539 55.353
R572 GND.n4500 GND.n4499 55.353
R573 GND.n4460 GND.n4459 55.353
R574 GND.n4420 GND.n4419 55.353
R575 GND.n4380 GND.n4379 55.353
R576 GND.n4340 GND.n4339 55.353
R577 GND.n4300 GND.n4299 55.353
R578 GND.n4260 GND.n4259 55.353
R579 GND.n2909 GND.n2908 55.353
R580 GND.n2869 GND.n2868 55.353
R581 GND.n2829 GND.n2828 55.353
R582 GND.n2789 GND.n2788 55.353
R583 GND.n2749 GND.n2748 55.353
R584 GND.n2709 GND.n2708 55.353
R585 GND.n2669 GND.n2668 55.353
R586 GND.n2629 GND.n2628 55.353
R587 GND.n69 GND.n68 54.344
R588 GND.n242 GND.n241 54.344
R589 GND.n201 GND.n200 54.344
R590 GND.n161 GND.n160 54.344
R591 GND.n170 GND.n169 54.344
R592 GND.n121 GND.n120 54.344
R593 GND.n130 GND.n129 54.344
R594 GND.n580 GND.n579 54.344
R595 GND.n538 GND.n537 54.344
R596 GND.n496 GND.n495 54.344
R597 GND.n455 GND.n454 54.344
R598 GND.n415 GND.n414 54.344
R599 GND.n424 GND.n423 54.344
R600 GND.n375 GND.n374 54.344
R601 GND.n384 GND.n383 54.344
R602 GND.n335 GND.n334 54.344
R603 GND.n344 GND.n343 54.344
R604 GND.n295 GND.n294 54.344
R605 GND.n304 GND.n303 54.344
R606 GND.n1246 GND.n1245 54.344
R607 GND.n1204 GND.n1203 54.344
R608 GND.n1162 GND.n1161 54.344
R609 GND.n1120 GND.n1119 54.344
R610 GND.n1078 GND.n1077 54.344
R611 GND.n1036 GND.n1035 54.344
R612 GND.n994 GND.n993 54.344
R613 GND.n953 GND.n952 54.344
R614 GND.n913 GND.n912 54.344
R615 GND.n922 GND.n921 54.344
R616 GND.n873 GND.n872 54.344
R617 GND.n882 GND.n881 54.344
R618 GND.n833 GND.n832 54.344
R619 GND.n842 GND.n841 54.344
R620 GND.n793 GND.n792 54.344
R621 GND.n802 GND.n801 54.344
R622 GND.n753 GND.n752 54.344
R623 GND.n762 GND.n761 54.344
R624 GND.n713 GND.n712 54.344
R625 GND.n722 GND.n721 54.344
R626 GND.n673 GND.n672 54.344
R627 GND.n682 GND.n681 54.344
R628 GND.n633 GND.n632 54.344
R629 GND.n642 GND.n641 54.344
R630 GND.n2568 GND.n2567 54.344
R631 GND.n2526 GND.n2525 54.344
R632 GND.n2484 GND.n2483 54.344
R633 GND.n2442 GND.n2441 54.344
R634 GND.n2400 GND.n2399 54.344
R635 GND.n2358 GND.n2357 54.344
R636 GND.n2316 GND.n2315 54.344
R637 GND.n2274 GND.n2273 54.344
R638 GND.n2232 GND.n2231 54.344
R639 GND.n2190 GND.n2189 54.344
R640 GND.n2148 GND.n2147 54.344
R641 GND.n2106 GND.n2105 54.344
R642 GND.n2064 GND.n2063 54.344
R643 GND.n2022 GND.n2021 54.344
R644 GND.n1980 GND.n1979 54.344
R645 GND.n1939 GND.n1938 54.344
R646 GND.n1899 GND.n1898 54.344
R647 GND.n1908 GND.n1907 54.344
R648 GND.n1859 GND.n1858 54.344
R649 GND.n1868 GND.n1867 54.344
R650 GND.n1819 GND.n1818 54.344
R651 GND.n1828 GND.n1827 54.344
R652 GND.n1779 GND.n1778 54.344
R653 GND.n1788 GND.n1787 54.344
R654 GND.n1739 GND.n1738 54.344
R655 GND.n1748 GND.n1747 54.344
R656 GND.n1699 GND.n1698 54.344
R657 GND.n1708 GND.n1707 54.344
R658 GND.n1659 GND.n1658 54.344
R659 GND.n1668 GND.n1667 54.344
R660 GND.n1619 GND.n1618 54.344
R661 GND.n1628 GND.n1627 54.344
R662 GND.n1579 GND.n1578 54.344
R663 GND.n1588 GND.n1587 54.344
R664 GND.n1539 GND.n1538 54.344
R665 GND.n1548 GND.n1547 54.344
R666 GND.n1499 GND.n1498 54.344
R667 GND.n1508 GND.n1507 54.344
R668 GND.n1459 GND.n1458 54.344
R669 GND.n1468 GND.n1467 54.344
R670 GND.n1419 GND.n1418 54.344
R671 GND.n1428 GND.n1427 54.344
R672 GND.n1379 GND.n1378 54.344
R673 GND.n1388 GND.n1387 54.344
R674 GND.n1339 GND.n1338 54.344
R675 GND.n1348 GND.n1347 54.344
R676 GND.n1299 GND.n1298 54.344
R677 GND.n1308 GND.n1307 54.344
R678 GND.n5202 GND.n5201 54.344
R679 GND.n5160 GND.n5159 54.344
R680 GND.n5118 GND.n5117 54.344
R681 GND.n5076 GND.n5075 54.344
R682 GND.n5034 GND.n5033 54.344
R683 GND.n4992 GND.n4991 54.344
R684 GND.n4950 GND.n4949 54.344
R685 GND.n4908 GND.n4907 54.344
R686 GND.n3554 GND.n3553 54.344
R687 GND.n3512 GND.n3511 54.344
R688 GND.n3470 GND.n3469 54.344
R689 GND.n3428 GND.n3427 54.344
R690 GND.n3386 GND.n3385 54.344
R691 GND.n3344 GND.n3343 54.344
R692 GND.n3302 GND.n3301 54.344
R693 GND.n3261 GND.n3260 54.344
R694 GND.n3221 GND.n3220 54.344
R695 GND.n3230 GND.n3229 54.344
R696 GND.n3181 GND.n3180 54.344
R697 GND.n3190 GND.n3189 54.344
R698 GND.n3141 GND.n3140 54.344
R699 GND.n3150 GND.n3149 54.344
R700 GND.n3101 GND.n3100 54.344
R701 GND.n3110 GND.n3109 54.344
R702 GND.n3061 GND.n3060 54.344
R703 GND.n3070 GND.n3069 54.344
R704 GND.n3021 GND.n3020 54.344
R705 GND.n3030 GND.n3029 54.344
R706 GND.n2981 GND.n2980 54.344
R707 GND.n2990 GND.n2989 54.344
R708 GND.n2941 GND.n2940 54.344
R709 GND.n2950 GND.n2949 54.344
R710 GND.n4209 GND.n4208 54.344
R711 GND.n4167 GND.n4166 54.344
R712 GND.n4125 GND.n4124 54.344
R713 GND.n4083 GND.n4082 54.344
R714 GND.n4041 GND.n4040 54.344
R715 GND.n3999 GND.n3998 54.344
R716 GND.n3957 GND.n3956 54.344
R717 GND.n3916 GND.n3915 54.344
R718 GND.n3876 GND.n3875 54.344
R719 GND.n3885 GND.n3884 54.344
R720 GND.n3836 GND.n3835 54.344
R721 GND.n3845 GND.n3844 54.344
R722 GND.n3796 GND.n3795 54.344
R723 GND.n3805 GND.n3804 54.344
R724 GND.n3756 GND.n3755 54.344
R725 GND.n3765 GND.n3764 54.344
R726 GND.n3716 GND.n3715 54.344
R727 GND.n3725 GND.n3724 54.344
R728 GND.n3676 GND.n3675 54.344
R729 GND.n3685 GND.n3684 54.344
R730 GND.n3636 GND.n3635 54.344
R731 GND.n3645 GND.n3644 54.344
R732 GND.n3596 GND.n3595 54.344
R733 GND.n3605 GND.n3604 54.344
R734 GND.n4865 GND.n4864 54.344
R735 GND.n4823 GND.n4822 54.344
R736 GND.n4781 GND.n4780 54.344
R737 GND.n4739 GND.n4738 54.344
R738 GND.n4697 GND.n4696 54.344
R739 GND.n4655 GND.n4654 54.344
R740 GND.n4613 GND.n4612 54.344
R741 GND.n4572 GND.n4571 54.344
R742 GND.n4532 GND.n4531 54.344
R743 GND.n4541 GND.n4540 54.344
R744 GND.n4492 GND.n4491 54.344
R745 GND.n4501 GND.n4500 54.344
R746 GND.n4452 GND.n4451 54.344
R747 GND.n4461 GND.n4460 54.344
R748 GND.n4412 GND.n4411 54.344
R749 GND.n4421 GND.n4420 54.344
R750 GND.n4372 GND.n4371 54.344
R751 GND.n4381 GND.n4380 54.344
R752 GND.n4332 GND.n4331 54.344
R753 GND.n4341 GND.n4340 54.344
R754 GND.n4292 GND.n4291 54.344
R755 GND.n4301 GND.n4300 54.344
R756 GND.n4252 GND.n4251 54.344
R757 GND.n4261 GND.n4260 54.344
R758 GND.n2901 GND.n2900 54.344
R759 GND.n2910 GND.n2909 54.344
R760 GND.n2861 GND.n2860 54.344
R761 GND.n2870 GND.n2869 54.344
R762 GND.n2821 GND.n2820 54.344
R763 GND.n2830 GND.n2829 54.344
R764 GND.n2781 GND.n2780 54.344
R765 GND.n2790 GND.n2789 54.344
R766 GND.n2741 GND.n2740 54.344
R767 GND.n2750 GND.n2749 54.344
R768 GND.n2701 GND.n2700 54.344
R769 GND.n2710 GND.n2709 54.344
R770 GND.n2661 GND.n2660 54.344
R771 GND.n2670 GND.n2669 54.344
R772 GND.n2621 GND.n2620 54.344
R773 GND.n2630 GND.n2629 54.344
R774 GND.n51 GND.n50 47.551
R775 GND.n11 GND.n10 47.551
R776 GND.n43 GND.n42 47.551
R777 GND.n224 GND.n223 47.551
R778 GND.n183 GND.n182 47.551
R779 GND.n151 GND.n150 47.551
R780 GND.n111 GND.n110 47.551
R781 GND.n562 GND.n561 47.551
R782 GND.n520 GND.n519 47.551
R783 GND.n478 GND.n477 47.551
R784 GND.n437 GND.n436 47.551
R785 GND.n405 GND.n404 47.551
R786 GND.n365 GND.n364 47.551
R787 GND.n325 GND.n324 47.551
R788 GND.n285 GND.n284 47.551
R789 GND.n1228 GND.n1227 47.551
R790 GND.n1186 GND.n1185 47.551
R791 GND.n1144 GND.n1143 47.551
R792 GND.n1102 GND.n1101 47.551
R793 GND.n1060 GND.n1059 47.551
R794 GND.n1018 GND.n1017 47.551
R795 GND.n976 GND.n975 47.551
R796 GND.n935 GND.n934 47.551
R797 GND.n903 GND.n902 47.551
R798 GND.n863 GND.n862 47.551
R799 GND.n823 GND.n822 47.551
R800 GND.n783 GND.n782 47.551
R801 GND.n743 GND.n742 47.551
R802 GND.n703 GND.n702 47.551
R803 GND.n663 GND.n662 47.551
R804 GND.n623 GND.n622 47.551
R805 GND.n2550 GND.n2549 47.551
R806 GND.n2508 GND.n2507 47.551
R807 GND.n2466 GND.n2465 47.551
R808 GND.n2424 GND.n2423 47.551
R809 GND.n2382 GND.n2381 47.551
R810 GND.n2340 GND.n2339 47.551
R811 GND.n2298 GND.n2297 47.551
R812 GND.n2256 GND.n2255 47.551
R813 GND.n2214 GND.n2213 47.551
R814 GND.n2172 GND.n2171 47.551
R815 GND.n2130 GND.n2129 47.551
R816 GND.n2088 GND.n2087 47.551
R817 GND.n2046 GND.n2045 47.551
R818 GND.n2004 GND.n2003 47.551
R819 GND.n1962 GND.n1961 47.551
R820 GND.n1921 GND.n1920 47.551
R821 GND.n1889 GND.n1888 47.551
R822 GND.n1849 GND.n1848 47.551
R823 GND.n1809 GND.n1808 47.551
R824 GND.n1769 GND.n1768 47.551
R825 GND.n1729 GND.n1728 47.551
R826 GND.n1689 GND.n1688 47.551
R827 GND.n1649 GND.n1648 47.551
R828 GND.n1609 GND.n1608 47.551
R829 GND.n1569 GND.n1568 47.551
R830 GND.n1529 GND.n1528 47.551
R831 GND.n1489 GND.n1488 47.551
R832 GND.n1449 GND.n1448 47.551
R833 GND.n1409 GND.n1408 47.551
R834 GND.n1369 GND.n1368 47.551
R835 GND.n1329 GND.n1328 47.551
R836 GND.n1289 GND.n1288 47.551
R837 GND.n5184 GND.n5183 47.551
R838 GND.n5142 GND.n5141 47.551
R839 GND.n5100 GND.n5099 47.551
R840 GND.n5058 GND.n5057 47.551
R841 GND.n5016 GND.n5015 47.551
R842 GND.n4974 GND.n4973 47.551
R843 GND.n4932 GND.n4931 47.551
R844 GND.n4890 GND.n4889 47.551
R845 GND.n3536 GND.n3535 47.551
R846 GND.n3494 GND.n3493 47.551
R847 GND.n3452 GND.n3451 47.551
R848 GND.n3410 GND.n3409 47.551
R849 GND.n3368 GND.n3367 47.551
R850 GND.n3326 GND.n3325 47.551
R851 GND.n3284 GND.n3283 47.551
R852 GND.n3243 GND.n3242 47.551
R853 GND.n3211 GND.n3210 47.551
R854 GND.n3171 GND.n3170 47.551
R855 GND.n3131 GND.n3130 47.551
R856 GND.n3091 GND.n3090 47.551
R857 GND.n3051 GND.n3050 47.551
R858 GND.n3011 GND.n3010 47.551
R859 GND.n2971 GND.n2970 47.551
R860 GND.n2931 GND.n2930 47.551
R861 GND.n4191 GND.n4190 47.551
R862 GND.n4149 GND.n4148 47.551
R863 GND.n4107 GND.n4106 47.551
R864 GND.n4065 GND.n4064 47.551
R865 GND.n4023 GND.n4022 47.551
R866 GND.n3981 GND.n3980 47.551
R867 GND.n3939 GND.n3938 47.551
R868 GND.n3898 GND.n3897 47.551
R869 GND.n3866 GND.n3865 47.551
R870 GND.n3826 GND.n3825 47.551
R871 GND.n3786 GND.n3785 47.551
R872 GND.n3746 GND.n3745 47.551
R873 GND.n3706 GND.n3705 47.551
R874 GND.n3666 GND.n3665 47.551
R875 GND.n3626 GND.n3625 47.551
R876 GND.n3586 GND.n3585 47.551
R877 GND.n4847 GND.n4846 47.551
R878 GND.n4805 GND.n4804 47.551
R879 GND.n4763 GND.n4762 47.551
R880 GND.n4721 GND.n4720 47.551
R881 GND.n4679 GND.n4678 47.551
R882 GND.n4637 GND.n4636 47.551
R883 GND.n4595 GND.n4594 47.551
R884 GND.n4554 GND.n4553 47.551
R885 GND.n4522 GND.n4521 47.551
R886 GND.n4482 GND.n4481 47.551
R887 GND.n4442 GND.n4441 47.551
R888 GND.n4402 GND.n4401 47.551
R889 GND.n4362 GND.n4361 47.551
R890 GND.n4322 GND.n4321 47.551
R891 GND.n4282 GND.n4281 47.551
R892 GND.n4242 GND.n4241 47.551
R893 GND.n2891 GND.n2890 47.551
R894 GND.n2851 GND.n2850 47.551
R895 GND.n2811 GND.n2810 47.551
R896 GND.n2771 GND.n2770 47.551
R897 GND.n2731 GND.n2730 47.551
R898 GND.n2691 GND.n2690 47.551
R899 GND.n2651 GND.n2650 47.551
R900 GND.n2611 GND.n2610 47.551
R901 GND.n78 GND.n77 25.966
R902 GND.n77 GND.n76 25.966
R903 GND.n22 GND.n21 25.966
R904 GND.n30 GND.n29 25.966
R905 GND.n31 GND.n30 25.966
R906 GND.n21 GND.n20 25.966
R907 GND.n251 GND.n250 25.966
R908 GND.n210 GND.n209 25.966
R909 GND.n209 GND.n208 25.966
R910 GND.n250 GND.n249 25.966
R911 GND.n589 GND.n588 25.966
R912 GND.n547 GND.n546 25.966
R913 GND.n505 GND.n504 25.966
R914 GND.n464 GND.n463 25.966
R915 GND.n463 GND.n462 25.966
R916 GND.n504 GND.n503 25.966
R917 GND.n546 GND.n545 25.966
R918 GND.n588 GND.n587 25.966
R919 GND.n1255 GND.n1254 25.966
R920 GND.n1213 GND.n1212 25.966
R921 GND.n1171 GND.n1170 25.966
R922 GND.n1129 GND.n1128 25.966
R923 GND.n1087 GND.n1086 25.966
R924 GND.n1045 GND.n1044 25.966
R925 GND.n1003 GND.n1002 25.966
R926 GND.n962 GND.n961 25.966
R927 GND.n961 GND.n960 25.966
R928 GND.n1002 GND.n1001 25.966
R929 GND.n1044 GND.n1043 25.966
R930 GND.n1086 GND.n1085 25.966
R931 GND.n1128 GND.n1127 25.966
R932 GND.n1170 GND.n1169 25.966
R933 GND.n1212 GND.n1211 25.966
R934 GND.n1254 GND.n1253 25.966
R935 GND.n2577 GND.n2576 25.966
R936 GND.n2535 GND.n2534 25.966
R937 GND.n2493 GND.n2492 25.966
R938 GND.n2451 GND.n2450 25.966
R939 GND.n2409 GND.n2408 25.966
R940 GND.n2367 GND.n2366 25.966
R941 GND.n2325 GND.n2324 25.966
R942 GND.n2283 GND.n2282 25.966
R943 GND.n2241 GND.n2240 25.966
R944 GND.n2199 GND.n2198 25.966
R945 GND.n2157 GND.n2156 25.966
R946 GND.n2115 GND.n2114 25.966
R947 GND.n2073 GND.n2072 25.966
R948 GND.n2031 GND.n2030 25.966
R949 GND.n1989 GND.n1988 25.966
R950 GND.n1948 GND.n1947 25.966
R951 GND.n1947 GND.n1946 25.966
R952 GND.n1988 GND.n1987 25.966
R953 GND.n2030 GND.n2029 25.966
R954 GND.n2072 GND.n2071 25.966
R955 GND.n2114 GND.n2113 25.966
R956 GND.n2156 GND.n2155 25.966
R957 GND.n2198 GND.n2197 25.966
R958 GND.n2240 GND.n2239 25.966
R959 GND.n2282 GND.n2281 25.966
R960 GND.n2324 GND.n2323 25.966
R961 GND.n2366 GND.n2365 25.966
R962 GND.n2408 GND.n2407 25.966
R963 GND.n2450 GND.n2449 25.966
R964 GND.n2492 GND.n2491 25.966
R965 GND.n2534 GND.n2533 25.966
R966 GND.n2576 GND.n2575 25.966
R967 GND.n5211 GND.n5210 25.966
R968 GND.n5169 GND.n5168 25.966
R969 GND.n5127 GND.n5126 25.966
R970 GND.n5085 GND.n5084 25.966
R971 GND.n5043 GND.n5042 25.966
R972 GND.n5001 GND.n5000 25.966
R973 GND.n4959 GND.n4958 25.966
R974 GND.n4917 GND.n4916 25.966
R975 GND.n3563 GND.n3562 25.966
R976 GND.n3521 GND.n3520 25.966
R977 GND.n3479 GND.n3478 25.966
R978 GND.n3437 GND.n3436 25.966
R979 GND.n3395 GND.n3394 25.966
R980 GND.n3353 GND.n3352 25.966
R981 GND.n3311 GND.n3310 25.966
R982 GND.n3270 GND.n3269 25.966
R983 GND.n3269 GND.n3268 25.966
R984 GND.n3310 GND.n3309 25.966
R985 GND.n3352 GND.n3351 25.966
R986 GND.n3394 GND.n3393 25.966
R987 GND.n3436 GND.n3435 25.966
R988 GND.n3478 GND.n3477 25.966
R989 GND.n3520 GND.n3519 25.966
R990 GND.n3562 GND.n3561 25.966
R991 GND.n4218 GND.n4217 25.966
R992 GND.n4176 GND.n4175 25.966
R993 GND.n4134 GND.n4133 25.966
R994 GND.n4092 GND.n4091 25.966
R995 GND.n4050 GND.n4049 25.966
R996 GND.n4008 GND.n4007 25.966
R997 GND.n3966 GND.n3965 25.966
R998 GND.n3925 GND.n3924 25.966
R999 GND.n3924 GND.n3923 25.966
R1000 GND.n3965 GND.n3964 25.966
R1001 GND.n4007 GND.n4006 25.966
R1002 GND.n4049 GND.n4048 25.966
R1003 GND.n4091 GND.n4090 25.966
R1004 GND.n4133 GND.n4132 25.966
R1005 GND.n4175 GND.n4174 25.966
R1006 GND.n4217 GND.n4216 25.966
R1007 GND.n4874 GND.n4873 25.966
R1008 GND.n4832 GND.n4831 25.966
R1009 GND.n4790 GND.n4789 25.966
R1010 GND.n4748 GND.n4747 25.966
R1011 GND.n4706 GND.n4705 25.966
R1012 GND.n4664 GND.n4663 25.966
R1013 GND.n4622 GND.n4621 25.966
R1014 GND.n4581 GND.n4580 25.966
R1015 GND.n4580 GND.n4579 25.966
R1016 GND.n4621 GND.n4620 25.966
R1017 GND.n4663 GND.n4662 25.966
R1018 GND.n4705 GND.n4704 25.966
R1019 GND.n4747 GND.n4746 25.966
R1020 GND.n4789 GND.n4788 25.966
R1021 GND.n4831 GND.n4830 25.966
R1022 GND.n4873 GND.n4872 25.966
R1023 GND.n4916 GND.n4915 25.966
R1024 GND.n4958 GND.n4957 25.966
R1025 GND.n5000 GND.n4999 25.966
R1026 GND.n5042 GND.n5041 25.966
R1027 GND.n5084 GND.n5083 25.966
R1028 GND.n5126 GND.n5125 25.966
R1029 GND.n5168 GND.n5167 25.966
R1030 GND.n5210 GND.n5209 25.966
R1031 GND.n58 GND.n57 22.848
R1032 GND.n59 GND.n58 22.848
R1033 GND.n231 GND.n230 22.848
R1034 GND.n190 GND.n189 22.848
R1035 GND.n191 GND.n190 22.848
R1036 GND.n143 GND.n142 22.848
R1037 GND.n144 GND.n143 22.848
R1038 GND.n232 GND.n231 22.848
R1039 GND.n103 GND.n102 22.848
R1040 GND.n104 GND.n103 22.848
R1041 GND.n569 GND.n568 22.848
R1042 GND.n527 GND.n526 22.848
R1043 GND.n485 GND.n484 22.848
R1044 GND.n444 GND.n443 22.848
R1045 GND.n445 GND.n444 22.848
R1046 GND.n397 GND.n396 22.848
R1047 GND.n398 GND.n397 22.848
R1048 GND.n486 GND.n485 22.848
R1049 GND.n357 GND.n356 22.848
R1050 GND.n358 GND.n357 22.848
R1051 GND.n528 GND.n527 22.848
R1052 GND.n317 GND.n316 22.848
R1053 GND.n318 GND.n317 22.848
R1054 GND.n570 GND.n569 22.848
R1055 GND.n277 GND.n276 22.848
R1056 GND.n278 GND.n277 22.848
R1057 GND.n1235 GND.n1234 22.848
R1058 GND.n1193 GND.n1192 22.848
R1059 GND.n1151 GND.n1150 22.848
R1060 GND.n1109 GND.n1108 22.848
R1061 GND.n1067 GND.n1066 22.848
R1062 GND.n1025 GND.n1024 22.848
R1063 GND.n983 GND.n982 22.848
R1064 GND.n942 GND.n941 22.848
R1065 GND.n943 GND.n942 22.848
R1066 GND.n895 GND.n894 22.848
R1067 GND.n896 GND.n895 22.848
R1068 GND.n984 GND.n983 22.848
R1069 GND.n855 GND.n854 22.848
R1070 GND.n856 GND.n855 22.848
R1071 GND.n1026 GND.n1025 22.848
R1072 GND.n815 GND.n814 22.848
R1073 GND.n816 GND.n815 22.848
R1074 GND.n1068 GND.n1067 22.848
R1075 GND.n775 GND.n774 22.848
R1076 GND.n776 GND.n775 22.848
R1077 GND.n1110 GND.n1109 22.848
R1078 GND.n735 GND.n734 22.848
R1079 GND.n736 GND.n735 22.848
R1080 GND.n1152 GND.n1151 22.848
R1081 GND.n695 GND.n694 22.848
R1082 GND.n696 GND.n695 22.848
R1083 GND.n1194 GND.n1193 22.848
R1084 GND.n655 GND.n654 22.848
R1085 GND.n656 GND.n655 22.848
R1086 GND.n1236 GND.n1235 22.848
R1087 GND.n615 GND.n614 22.848
R1088 GND.n616 GND.n615 22.848
R1089 GND.n2557 GND.n2556 22.848
R1090 GND.n2515 GND.n2514 22.848
R1091 GND.n2473 GND.n2472 22.848
R1092 GND.n2431 GND.n2430 22.848
R1093 GND.n2389 GND.n2388 22.848
R1094 GND.n2347 GND.n2346 22.848
R1095 GND.n2305 GND.n2304 22.848
R1096 GND.n2263 GND.n2262 22.848
R1097 GND.n2221 GND.n2220 22.848
R1098 GND.n2179 GND.n2178 22.848
R1099 GND.n2137 GND.n2136 22.848
R1100 GND.n2095 GND.n2094 22.848
R1101 GND.n2053 GND.n2052 22.848
R1102 GND.n2011 GND.n2010 22.848
R1103 GND.n1969 GND.n1968 22.848
R1104 GND.n1928 GND.n1927 22.848
R1105 GND.n1929 GND.n1928 22.848
R1106 GND.n1881 GND.n1880 22.848
R1107 GND.n1882 GND.n1881 22.848
R1108 GND.n1970 GND.n1969 22.848
R1109 GND.n1841 GND.n1840 22.848
R1110 GND.n1842 GND.n1841 22.848
R1111 GND.n2012 GND.n2011 22.848
R1112 GND.n1801 GND.n1800 22.848
R1113 GND.n1802 GND.n1801 22.848
R1114 GND.n2054 GND.n2053 22.848
R1115 GND.n1761 GND.n1760 22.848
R1116 GND.n1762 GND.n1761 22.848
R1117 GND.n2096 GND.n2095 22.848
R1118 GND.n1721 GND.n1720 22.848
R1119 GND.n1722 GND.n1721 22.848
R1120 GND.n2138 GND.n2137 22.848
R1121 GND.n1681 GND.n1680 22.848
R1122 GND.n1682 GND.n1681 22.848
R1123 GND.n2180 GND.n2179 22.848
R1124 GND.n1641 GND.n1640 22.848
R1125 GND.n1642 GND.n1641 22.848
R1126 GND.n2222 GND.n2221 22.848
R1127 GND.n1601 GND.n1600 22.848
R1128 GND.n1602 GND.n1601 22.848
R1129 GND.n2264 GND.n2263 22.848
R1130 GND.n1561 GND.n1560 22.848
R1131 GND.n1562 GND.n1561 22.848
R1132 GND.n2306 GND.n2305 22.848
R1133 GND.n1521 GND.n1520 22.848
R1134 GND.n1522 GND.n1521 22.848
R1135 GND.n2348 GND.n2347 22.848
R1136 GND.n1481 GND.n1480 22.848
R1137 GND.n1482 GND.n1481 22.848
R1138 GND.n2390 GND.n2389 22.848
R1139 GND.n1441 GND.n1440 22.848
R1140 GND.n1442 GND.n1441 22.848
R1141 GND.n2432 GND.n2431 22.848
R1142 GND.n1401 GND.n1400 22.848
R1143 GND.n1402 GND.n1401 22.848
R1144 GND.n2474 GND.n2473 22.848
R1145 GND.n1361 GND.n1360 22.848
R1146 GND.n1362 GND.n1361 22.848
R1147 GND.n2516 GND.n2515 22.848
R1148 GND.n1321 GND.n1320 22.848
R1149 GND.n1322 GND.n1321 22.848
R1150 GND.n2558 GND.n2557 22.848
R1151 GND.n1281 GND.n1280 22.848
R1152 GND.n1282 GND.n1281 22.848
R1153 GND.n5191 GND.n5190 22.848
R1154 GND.n5149 GND.n5148 22.848
R1155 GND.n5107 GND.n5106 22.848
R1156 GND.n5065 GND.n5064 22.848
R1157 GND.n5023 GND.n5022 22.848
R1158 GND.n4981 GND.n4980 22.848
R1159 GND.n4939 GND.n4938 22.848
R1160 GND.n4897 GND.n4896 22.848
R1161 GND.n3543 GND.n3542 22.848
R1162 GND.n3501 GND.n3500 22.848
R1163 GND.n3459 GND.n3458 22.848
R1164 GND.n3417 GND.n3416 22.848
R1165 GND.n3375 GND.n3374 22.848
R1166 GND.n3333 GND.n3332 22.848
R1167 GND.n3291 GND.n3290 22.848
R1168 GND.n3250 GND.n3249 22.848
R1169 GND.n3251 GND.n3250 22.848
R1170 GND.n3203 GND.n3202 22.848
R1171 GND.n3204 GND.n3203 22.848
R1172 GND.n3292 GND.n3291 22.848
R1173 GND.n3163 GND.n3162 22.848
R1174 GND.n3164 GND.n3163 22.848
R1175 GND.n3334 GND.n3333 22.848
R1176 GND.n3123 GND.n3122 22.848
R1177 GND.n3124 GND.n3123 22.848
R1178 GND.n3376 GND.n3375 22.848
R1179 GND.n3083 GND.n3082 22.848
R1180 GND.n3084 GND.n3083 22.848
R1181 GND.n3418 GND.n3417 22.848
R1182 GND.n3043 GND.n3042 22.848
R1183 GND.n3044 GND.n3043 22.848
R1184 GND.n3460 GND.n3459 22.848
R1185 GND.n3003 GND.n3002 22.848
R1186 GND.n3004 GND.n3003 22.848
R1187 GND.n3502 GND.n3501 22.848
R1188 GND.n2963 GND.n2962 22.848
R1189 GND.n2964 GND.n2963 22.848
R1190 GND.n3544 GND.n3543 22.848
R1191 GND.n2923 GND.n2922 22.848
R1192 GND.n2924 GND.n2923 22.848
R1193 GND.n4198 GND.n4197 22.848
R1194 GND.n4156 GND.n4155 22.848
R1195 GND.n4114 GND.n4113 22.848
R1196 GND.n4072 GND.n4071 22.848
R1197 GND.n4030 GND.n4029 22.848
R1198 GND.n3988 GND.n3987 22.848
R1199 GND.n3946 GND.n3945 22.848
R1200 GND.n3905 GND.n3904 22.848
R1201 GND.n3906 GND.n3905 22.848
R1202 GND.n3858 GND.n3857 22.848
R1203 GND.n3859 GND.n3858 22.848
R1204 GND.n3947 GND.n3946 22.848
R1205 GND.n3818 GND.n3817 22.848
R1206 GND.n3819 GND.n3818 22.848
R1207 GND.n3989 GND.n3988 22.848
R1208 GND.n3778 GND.n3777 22.848
R1209 GND.n3779 GND.n3778 22.848
R1210 GND.n4031 GND.n4030 22.848
R1211 GND.n3738 GND.n3737 22.848
R1212 GND.n3739 GND.n3738 22.848
R1213 GND.n4073 GND.n4072 22.848
R1214 GND.n3698 GND.n3697 22.848
R1215 GND.n3699 GND.n3698 22.848
R1216 GND.n4115 GND.n4114 22.848
R1217 GND.n3658 GND.n3657 22.848
R1218 GND.n3659 GND.n3658 22.848
R1219 GND.n4157 GND.n4156 22.848
R1220 GND.n3618 GND.n3617 22.848
R1221 GND.n3619 GND.n3618 22.848
R1222 GND.n4199 GND.n4198 22.848
R1223 GND.n3578 GND.n3577 22.848
R1224 GND.n3579 GND.n3578 22.848
R1225 GND.n4854 GND.n4853 22.848
R1226 GND.n4812 GND.n4811 22.848
R1227 GND.n4770 GND.n4769 22.848
R1228 GND.n4728 GND.n4727 22.848
R1229 GND.n4686 GND.n4685 22.848
R1230 GND.n4644 GND.n4643 22.848
R1231 GND.n4602 GND.n4601 22.848
R1232 GND.n4561 GND.n4560 22.848
R1233 GND.n4562 GND.n4561 22.848
R1234 GND.n4514 GND.n4513 22.848
R1235 GND.n4515 GND.n4514 22.848
R1236 GND.n4603 GND.n4602 22.848
R1237 GND.n4474 GND.n4473 22.848
R1238 GND.n4475 GND.n4474 22.848
R1239 GND.n4645 GND.n4644 22.848
R1240 GND.n4434 GND.n4433 22.848
R1241 GND.n4435 GND.n4434 22.848
R1242 GND.n4687 GND.n4686 22.848
R1243 GND.n4394 GND.n4393 22.848
R1244 GND.n4395 GND.n4394 22.848
R1245 GND.n4729 GND.n4728 22.848
R1246 GND.n4354 GND.n4353 22.848
R1247 GND.n4355 GND.n4354 22.848
R1248 GND.n4771 GND.n4770 22.848
R1249 GND.n4314 GND.n4313 22.848
R1250 GND.n4315 GND.n4314 22.848
R1251 GND.n4813 GND.n4812 22.848
R1252 GND.n4274 GND.n4273 22.848
R1253 GND.n4275 GND.n4274 22.848
R1254 GND.n4855 GND.n4854 22.848
R1255 GND.n4234 GND.n4233 22.848
R1256 GND.n4235 GND.n4234 22.848
R1257 GND.n4898 GND.n4897 22.848
R1258 GND.n2883 GND.n2882 22.848
R1259 GND.n2884 GND.n2883 22.848
R1260 GND.n4940 GND.n4939 22.848
R1261 GND.n2843 GND.n2842 22.848
R1262 GND.n2844 GND.n2843 22.848
R1263 GND.n4982 GND.n4981 22.848
R1264 GND.n2803 GND.n2802 22.848
R1265 GND.n2804 GND.n2803 22.848
R1266 GND.n5024 GND.n5023 22.848
R1267 GND.n2763 GND.n2762 22.848
R1268 GND.n2764 GND.n2763 22.848
R1269 GND.n5066 GND.n5065 22.848
R1270 GND.n2723 GND.n2722 22.848
R1271 GND.n2724 GND.n2723 22.848
R1272 GND.n5108 GND.n5107 22.848
R1273 GND.n2683 GND.n2682 22.848
R1274 GND.n2684 GND.n2683 22.848
R1275 GND.n5150 GND.n5149 22.848
R1276 GND.n2643 GND.n2642 22.848
R1277 GND.n2644 GND.n2643 22.848
R1278 GND.n5192 GND.n5191 22.848
R1279 GND.n2603 GND.n2602 22.848
R1280 GND.n2604 GND.n2603 22.848
R1281 GND.n60 GND.n59 10.189
R1282 GND.n233 GND.n232 10.189
R1283 GND.n192 GND.n191 10.189
R1284 GND.n146 GND.n144 10.189
R1285 GND.n106 GND.n104 10.189
R1286 GND.n571 GND.n570 10.189
R1287 GND.n529 GND.n528 10.189
R1288 GND.n487 GND.n486 10.189
R1289 GND.n446 GND.n445 10.189
R1290 GND.n400 GND.n398 10.189
R1291 GND.n360 GND.n358 10.189
R1292 GND.n320 GND.n318 10.189
R1293 GND.n280 GND.n278 10.189
R1294 GND.n1237 GND.n1236 10.189
R1295 GND.n1195 GND.n1194 10.189
R1296 GND.n1153 GND.n1152 10.189
R1297 GND.n1111 GND.n1110 10.189
R1298 GND.n1069 GND.n1068 10.189
R1299 GND.n1027 GND.n1026 10.189
R1300 GND.n985 GND.n984 10.189
R1301 GND.n944 GND.n943 10.189
R1302 GND.n898 GND.n896 10.189
R1303 GND.n858 GND.n856 10.189
R1304 GND.n818 GND.n816 10.189
R1305 GND.n778 GND.n776 10.189
R1306 GND.n738 GND.n736 10.189
R1307 GND.n698 GND.n696 10.189
R1308 GND.n658 GND.n656 10.189
R1309 GND.n618 GND.n616 10.189
R1310 GND.n2559 GND.n2558 10.189
R1311 GND.n2517 GND.n2516 10.189
R1312 GND.n2475 GND.n2474 10.189
R1313 GND.n2433 GND.n2432 10.189
R1314 GND.n2391 GND.n2390 10.189
R1315 GND.n2349 GND.n2348 10.189
R1316 GND.n2307 GND.n2306 10.189
R1317 GND.n2265 GND.n2264 10.189
R1318 GND.n2223 GND.n2222 10.189
R1319 GND.n2181 GND.n2180 10.189
R1320 GND.n2139 GND.n2138 10.189
R1321 GND.n2097 GND.n2096 10.189
R1322 GND.n2055 GND.n2054 10.189
R1323 GND.n2013 GND.n2012 10.189
R1324 GND.n1971 GND.n1970 10.189
R1325 GND.n1930 GND.n1929 10.189
R1326 GND.n1884 GND.n1882 10.189
R1327 GND.n1844 GND.n1842 10.189
R1328 GND.n1804 GND.n1802 10.189
R1329 GND.n1764 GND.n1762 10.189
R1330 GND.n1724 GND.n1722 10.189
R1331 GND.n1684 GND.n1682 10.189
R1332 GND.n1644 GND.n1642 10.189
R1333 GND.n1604 GND.n1602 10.189
R1334 GND.n1564 GND.n1562 10.189
R1335 GND.n1524 GND.n1522 10.189
R1336 GND.n1484 GND.n1482 10.189
R1337 GND.n1444 GND.n1442 10.189
R1338 GND.n1404 GND.n1402 10.189
R1339 GND.n1364 GND.n1362 10.189
R1340 GND.n1324 GND.n1322 10.189
R1341 GND.n1284 GND.n1282 10.189
R1342 GND.n5193 GND.n5192 10.189
R1343 GND.n5151 GND.n5150 10.189
R1344 GND.n5109 GND.n5108 10.189
R1345 GND.n5067 GND.n5066 10.189
R1346 GND.n5025 GND.n5024 10.189
R1347 GND.n4983 GND.n4982 10.189
R1348 GND.n4941 GND.n4940 10.189
R1349 GND.n4899 GND.n4898 10.189
R1350 GND.n3545 GND.n3544 10.189
R1351 GND.n3503 GND.n3502 10.189
R1352 GND.n3461 GND.n3460 10.189
R1353 GND.n3419 GND.n3418 10.189
R1354 GND.n3377 GND.n3376 10.189
R1355 GND.n3335 GND.n3334 10.189
R1356 GND.n3293 GND.n3292 10.189
R1357 GND.n3252 GND.n3251 10.189
R1358 GND.n3206 GND.n3204 10.189
R1359 GND.n3166 GND.n3164 10.189
R1360 GND.n3126 GND.n3124 10.189
R1361 GND.n3086 GND.n3084 10.189
R1362 GND.n3046 GND.n3044 10.189
R1363 GND.n3006 GND.n3004 10.189
R1364 GND.n2966 GND.n2964 10.189
R1365 GND.n2926 GND.n2924 10.189
R1366 GND.n4200 GND.n4199 10.189
R1367 GND.n4158 GND.n4157 10.189
R1368 GND.n4116 GND.n4115 10.189
R1369 GND.n4074 GND.n4073 10.189
R1370 GND.n4032 GND.n4031 10.189
R1371 GND.n3990 GND.n3989 10.189
R1372 GND.n3948 GND.n3947 10.189
R1373 GND.n3907 GND.n3906 10.189
R1374 GND.n3861 GND.n3859 10.189
R1375 GND.n3821 GND.n3819 10.189
R1376 GND.n3781 GND.n3779 10.189
R1377 GND.n3741 GND.n3739 10.189
R1378 GND.n3701 GND.n3699 10.189
R1379 GND.n3661 GND.n3659 10.189
R1380 GND.n3621 GND.n3619 10.189
R1381 GND.n3581 GND.n3579 10.189
R1382 GND.n4856 GND.n4855 10.189
R1383 GND.n4814 GND.n4813 10.189
R1384 GND.n4772 GND.n4771 10.189
R1385 GND.n4730 GND.n4729 10.189
R1386 GND.n4688 GND.n4687 10.189
R1387 GND.n4646 GND.n4645 10.189
R1388 GND.n4604 GND.n4603 10.189
R1389 GND.n4563 GND.n4562 10.189
R1390 GND.n4517 GND.n4515 10.189
R1391 GND.n4477 GND.n4475 10.189
R1392 GND.n4437 GND.n4435 10.189
R1393 GND.n4397 GND.n4395 10.189
R1394 GND.n4357 GND.n4355 10.189
R1395 GND.n4317 GND.n4315 10.189
R1396 GND.n4277 GND.n4275 10.189
R1397 GND.n4237 GND.n4235 10.189
R1398 GND.n2886 GND.n2884 10.189
R1399 GND.n2846 GND.n2844 10.189
R1400 GND.n2806 GND.n2804 10.189
R1401 GND.n2766 GND.n2764 10.189
R1402 GND.n2726 GND.n2724 10.189
R1403 GND.n2686 GND.n2684 10.189
R1404 GND.n2646 GND.n2644 10.189
R1405 GND.n2606 GND.n2604 10.189
R1406 GND.n2293 GND.n2252 9.956
R1407 GND.n53 GND.n51 9.861
R1408 GND.n45 GND.n43 9.861
R1409 GND.n12 GND.n11 9.861
R1410 GND.n185 GND.n183 9.861
R1411 GND.n152 GND.n151 9.861
R1412 GND.n226 GND.n224 9.861
R1413 GND.n112 GND.n111 9.861
R1414 GND.n439 GND.n437 9.861
R1415 GND.n406 GND.n405 9.861
R1416 GND.n480 GND.n478 9.861
R1417 GND.n366 GND.n365 9.861
R1418 GND.n522 GND.n520 9.861
R1419 GND.n326 GND.n325 9.861
R1420 GND.n564 GND.n562 9.861
R1421 GND.n286 GND.n285 9.861
R1422 GND.n937 GND.n935 9.861
R1423 GND.n904 GND.n903 9.861
R1424 GND.n978 GND.n976 9.861
R1425 GND.n864 GND.n863 9.861
R1426 GND.n1020 GND.n1018 9.861
R1427 GND.n824 GND.n823 9.861
R1428 GND.n1062 GND.n1060 9.861
R1429 GND.n784 GND.n783 9.861
R1430 GND.n1104 GND.n1102 9.861
R1431 GND.n744 GND.n743 9.861
R1432 GND.n1146 GND.n1144 9.861
R1433 GND.n704 GND.n703 9.861
R1434 GND.n1188 GND.n1186 9.861
R1435 GND.n664 GND.n663 9.861
R1436 GND.n1230 GND.n1228 9.861
R1437 GND.n624 GND.n623 9.861
R1438 GND.n1923 GND.n1921 9.861
R1439 GND.n1890 GND.n1889 9.861
R1440 GND.n1964 GND.n1962 9.861
R1441 GND.n1850 GND.n1849 9.861
R1442 GND.n2006 GND.n2004 9.861
R1443 GND.n1810 GND.n1809 9.861
R1444 GND.n2048 GND.n2046 9.861
R1445 GND.n1770 GND.n1769 9.861
R1446 GND.n2090 GND.n2088 9.861
R1447 GND.n1730 GND.n1729 9.861
R1448 GND.n2132 GND.n2130 9.861
R1449 GND.n1690 GND.n1689 9.861
R1450 GND.n2174 GND.n2172 9.861
R1451 GND.n1650 GND.n1649 9.861
R1452 GND.n2216 GND.n2214 9.861
R1453 GND.n1610 GND.n1609 9.861
R1454 GND.n2258 GND.n2256 9.861
R1455 GND.n1570 GND.n1569 9.861
R1456 GND.n2300 GND.n2298 9.861
R1457 GND.n1530 GND.n1529 9.861
R1458 GND.n2342 GND.n2340 9.861
R1459 GND.n1490 GND.n1489 9.861
R1460 GND.n2384 GND.n2382 9.861
R1461 GND.n1450 GND.n1449 9.861
R1462 GND.n2426 GND.n2424 9.861
R1463 GND.n1410 GND.n1409 9.861
R1464 GND.n2468 GND.n2466 9.861
R1465 GND.n1370 GND.n1369 9.861
R1466 GND.n2510 GND.n2508 9.861
R1467 GND.n1330 GND.n1329 9.861
R1468 GND.n2552 GND.n2550 9.861
R1469 GND.n1290 GND.n1289 9.861
R1470 GND.n3245 GND.n3243 9.861
R1471 GND.n3212 GND.n3211 9.861
R1472 GND.n3286 GND.n3284 9.861
R1473 GND.n3172 GND.n3171 9.861
R1474 GND.n3328 GND.n3326 9.861
R1475 GND.n3132 GND.n3131 9.861
R1476 GND.n3370 GND.n3368 9.861
R1477 GND.n3092 GND.n3091 9.861
R1478 GND.n3412 GND.n3410 9.861
R1479 GND.n3052 GND.n3051 9.861
R1480 GND.n3454 GND.n3452 9.861
R1481 GND.n3012 GND.n3011 9.861
R1482 GND.n3496 GND.n3494 9.861
R1483 GND.n2972 GND.n2971 9.861
R1484 GND.n3538 GND.n3536 9.861
R1485 GND.n2932 GND.n2931 9.861
R1486 GND.n3900 GND.n3898 9.861
R1487 GND.n3867 GND.n3866 9.861
R1488 GND.n3941 GND.n3939 9.861
R1489 GND.n3827 GND.n3826 9.861
R1490 GND.n3983 GND.n3981 9.861
R1491 GND.n3787 GND.n3786 9.861
R1492 GND.n4025 GND.n4023 9.861
R1493 GND.n3747 GND.n3746 9.861
R1494 GND.n4067 GND.n4065 9.861
R1495 GND.n3707 GND.n3706 9.861
R1496 GND.n4109 GND.n4107 9.861
R1497 GND.n3667 GND.n3666 9.861
R1498 GND.n4151 GND.n4149 9.861
R1499 GND.n3627 GND.n3626 9.861
R1500 GND.n4193 GND.n4191 9.861
R1501 GND.n3587 GND.n3586 9.861
R1502 GND.n4556 GND.n4554 9.861
R1503 GND.n4523 GND.n4522 9.861
R1504 GND.n4597 GND.n4595 9.861
R1505 GND.n4483 GND.n4482 9.861
R1506 GND.n4639 GND.n4637 9.861
R1507 GND.n4443 GND.n4442 9.861
R1508 GND.n4681 GND.n4679 9.861
R1509 GND.n4403 GND.n4402 9.861
R1510 GND.n4723 GND.n4721 9.861
R1511 GND.n4363 GND.n4362 9.861
R1512 GND.n4765 GND.n4763 9.861
R1513 GND.n4323 GND.n4322 9.861
R1514 GND.n4807 GND.n4805 9.861
R1515 GND.n4283 GND.n4282 9.861
R1516 GND.n4849 GND.n4847 9.861
R1517 GND.n4243 GND.n4242 9.861
R1518 GND.n4892 GND.n4890 9.861
R1519 GND.n2892 GND.n2891 9.861
R1520 GND.n4934 GND.n4932 9.861
R1521 GND.n2852 GND.n2851 9.861
R1522 GND.n4976 GND.n4974 9.861
R1523 GND.n2812 GND.n2811 9.861
R1524 GND.n5018 GND.n5016 9.861
R1525 GND.n2772 GND.n2771 9.861
R1526 GND.n5060 GND.n5058 9.861
R1527 GND.n2732 GND.n2731 9.861
R1528 GND.n5102 GND.n5100 9.861
R1529 GND.n2692 GND.n2691 9.861
R1530 GND.n5144 GND.n5142 9.861
R1531 GND.n2652 GND.n2651 9.861
R1532 GND.n5186 GND.n5184 9.861
R1533 GND.n2612 GND.n2611 9.861
R1534 GND.n5226 GND.n5225 9.828
R1535 GND.n54 GND.n53 9.457
R1536 GND.n13 GND.n12 9.457
R1537 GND.n46 GND.n45 9.457
R1538 GND.n227 GND.n226 9.457
R1539 GND.n186 GND.n185 9.457
R1540 GND.n153 GND.n152 9.457
R1541 GND.n113 GND.n112 9.457
R1542 GND.n565 GND.n564 9.457
R1543 GND.n523 GND.n522 9.457
R1544 GND.n481 GND.n480 9.457
R1545 GND.n440 GND.n439 9.457
R1546 GND.n407 GND.n406 9.457
R1547 GND.n367 GND.n366 9.457
R1548 GND.n327 GND.n326 9.457
R1549 GND.n287 GND.n286 9.457
R1550 GND.n1231 GND.n1230 9.457
R1551 GND.n1189 GND.n1188 9.457
R1552 GND.n1147 GND.n1146 9.457
R1553 GND.n1105 GND.n1104 9.457
R1554 GND.n1063 GND.n1062 9.457
R1555 GND.n1021 GND.n1020 9.457
R1556 GND.n979 GND.n978 9.457
R1557 GND.n938 GND.n937 9.457
R1558 GND.n905 GND.n904 9.457
R1559 GND.n865 GND.n864 9.457
R1560 GND.n825 GND.n824 9.457
R1561 GND.n785 GND.n784 9.457
R1562 GND.n745 GND.n744 9.457
R1563 GND.n705 GND.n704 9.457
R1564 GND.n665 GND.n664 9.457
R1565 GND.n625 GND.n624 9.457
R1566 GND.n2553 GND.n2552 9.457
R1567 GND.n2511 GND.n2510 9.457
R1568 GND.n2469 GND.n2468 9.457
R1569 GND.n2427 GND.n2426 9.457
R1570 GND.n2385 GND.n2384 9.457
R1571 GND.n2343 GND.n2342 9.457
R1572 GND.n2301 GND.n2300 9.457
R1573 GND.n2259 GND.n2258 9.457
R1574 GND.n2217 GND.n2216 9.457
R1575 GND.n2175 GND.n2174 9.457
R1576 GND.n2133 GND.n2132 9.457
R1577 GND.n2091 GND.n2090 9.457
R1578 GND.n2049 GND.n2048 9.457
R1579 GND.n2007 GND.n2006 9.457
R1580 GND.n1965 GND.n1964 9.457
R1581 GND.n1924 GND.n1923 9.457
R1582 GND.n1891 GND.n1890 9.457
R1583 GND.n1851 GND.n1850 9.457
R1584 GND.n1811 GND.n1810 9.457
R1585 GND.n1771 GND.n1770 9.457
R1586 GND.n1731 GND.n1730 9.457
R1587 GND.n1691 GND.n1690 9.457
R1588 GND.n1651 GND.n1650 9.457
R1589 GND.n1611 GND.n1610 9.457
R1590 GND.n1571 GND.n1570 9.457
R1591 GND.n1531 GND.n1530 9.457
R1592 GND.n1491 GND.n1490 9.457
R1593 GND.n1451 GND.n1450 9.457
R1594 GND.n1411 GND.n1410 9.457
R1595 GND.n1371 GND.n1370 9.457
R1596 GND.n1331 GND.n1330 9.457
R1597 GND.n1291 GND.n1290 9.457
R1598 GND.n5187 GND.n5186 9.457
R1599 GND.n5145 GND.n5144 9.457
R1600 GND.n5103 GND.n5102 9.457
R1601 GND.n5061 GND.n5060 9.457
R1602 GND.n5019 GND.n5018 9.457
R1603 GND.n4977 GND.n4976 9.457
R1604 GND.n4935 GND.n4934 9.457
R1605 GND.n4893 GND.n4892 9.457
R1606 GND.n3539 GND.n3538 9.457
R1607 GND.n3497 GND.n3496 9.457
R1608 GND.n3455 GND.n3454 9.457
R1609 GND.n3413 GND.n3412 9.457
R1610 GND.n3371 GND.n3370 9.457
R1611 GND.n3329 GND.n3328 9.457
R1612 GND.n3287 GND.n3286 9.457
R1613 GND.n3246 GND.n3245 9.457
R1614 GND.n3213 GND.n3212 9.457
R1615 GND.n3173 GND.n3172 9.457
R1616 GND.n3133 GND.n3132 9.457
R1617 GND.n3093 GND.n3092 9.457
R1618 GND.n3053 GND.n3052 9.457
R1619 GND.n3013 GND.n3012 9.457
R1620 GND.n2973 GND.n2972 9.457
R1621 GND.n2933 GND.n2932 9.457
R1622 GND.n4194 GND.n4193 9.457
R1623 GND.n4152 GND.n4151 9.457
R1624 GND.n4110 GND.n4109 9.457
R1625 GND.n4068 GND.n4067 9.457
R1626 GND.n4026 GND.n4025 9.457
R1627 GND.n3984 GND.n3983 9.457
R1628 GND.n3942 GND.n3941 9.457
R1629 GND.n3901 GND.n3900 9.457
R1630 GND.n3868 GND.n3867 9.457
R1631 GND.n3828 GND.n3827 9.457
R1632 GND.n3788 GND.n3787 9.457
R1633 GND.n3748 GND.n3747 9.457
R1634 GND.n3708 GND.n3707 9.457
R1635 GND.n3668 GND.n3667 9.457
R1636 GND.n3628 GND.n3627 9.457
R1637 GND.n3588 GND.n3587 9.457
R1638 GND.n4850 GND.n4849 9.457
R1639 GND.n4808 GND.n4807 9.457
R1640 GND.n4766 GND.n4765 9.457
R1641 GND.n4724 GND.n4723 9.457
R1642 GND.n4682 GND.n4681 9.457
R1643 GND.n4640 GND.n4639 9.457
R1644 GND.n4598 GND.n4597 9.457
R1645 GND.n4557 GND.n4556 9.457
R1646 GND.n4524 GND.n4523 9.457
R1647 GND.n4484 GND.n4483 9.457
R1648 GND.n4444 GND.n4443 9.457
R1649 GND.n4404 GND.n4403 9.457
R1650 GND.n4364 GND.n4363 9.457
R1651 GND.n4324 GND.n4323 9.457
R1652 GND.n4284 GND.n4283 9.457
R1653 GND.n4244 GND.n4243 9.457
R1654 GND.n2893 GND.n2892 9.457
R1655 GND.n2853 GND.n2852 9.457
R1656 GND.n2813 GND.n2812 9.457
R1657 GND.n2773 GND.n2772 9.457
R1658 GND.n2733 GND.n2732 9.457
R1659 GND.n2693 GND.n2692 9.457
R1660 GND.n2653 GND.n2652 9.457
R1661 GND.n2613 GND.n2612 9.457
R1662 GND.n84 GND.n83 9.3
R1663 GND.n65 GND.n64 9.3
R1664 GND.n63 GND.n62 9.3
R1665 GND.n86 GND.n85 9.3
R1666 GND.n73 GND.n72 9.3
R1667 GND.n72 GND.n71 9.3
R1668 GND.n82 GND.n81 9.3
R1669 GND.n81 GND.n80 9.3
R1670 GND.n61 GND.n60 9.3
R1671 GND.n26 GND.n25 9.3
R1672 GND.n25 GND.n24 9.3
R1673 GND.n37 GND.n36 9.3
R1674 GND.n39 GND.n38 9.3
R1675 GND.n35 GND.n34 9.3
R1676 GND.n34 GND.n33 9.3
R1677 GND.n17 GND.n16 9.3
R1678 GND.n15 GND.n14 9.3
R1679 GND.n216 GND.n215 9.3
R1680 GND.n197 GND.n196 9.3
R1681 GND.n195 GND.n194 9.3
R1682 GND.n218 GND.n217 9.3
R1683 GND.n205 GND.n204 9.3
R1684 GND.n204 GND.n203 9.3
R1685 GND.n214 GND.n213 9.3
R1686 GND.n213 GND.n212 9.3
R1687 GND.n193 GND.n192 9.3
R1688 GND.n176 GND.n175 9.3
R1689 GND.n157 GND.n156 9.3
R1690 GND.n155 GND.n154 9.3
R1691 GND.n165 GND.n164 9.3
R1692 GND.n164 GND.n163 9.3
R1693 GND.n174 GND.n173 9.3
R1694 GND.n173 GND.n172 9.3
R1695 GND.n178 GND.n177 9.3
R1696 GND.n147 GND.n146 9.3
R1697 GND.n146 GND.n145 9.3
R1698 GND.n257 GND.n256 9.3
R1699 GND.n238 GND.n237 9.3
R1700 GND.n236 GND.n235 9.3
R1701 GND.n259 GND.n258 9.3
R1702 GND.n246 GND.n245 9.3
R1703 GND.n245 GND.n244 9.3
R1704 GND.n255 GND.n254 9.3
R1705 GND.n254 GND.n253 9.3
R1706 GND.n234 GND.n233 9.3
R1707 GND.n136 GND.n135 9.3
R1708 GND.n117 GND.n116 9.3
R1709 GND.n115 GND.n114 9.3
R1710 GND.n125 GND.n124 9.3
R1711 GND.n124 GND.n123 9.3
R1712 GND.n134 GND.n133 9.3
R1713 GND.n133 GND.n132 9.3
R1714 GND.n138 GND.n137 9.3
R1715 GND.n107 GND.n106 9.3
R1716 GND.n106 GND.n105 9.3
R1717 GND.n470 GND.n469 9.3
R1718 GND.n451 GND.n450 9.3
R1719 GND.n449 GND.n448 9.3
R1720 GND.n472 GND.n471 9.3
R1721 GND.n459 GND.n458 9.3
R1722 GND.n458 GND.n457 9.3
R1723 GND.n468 GND.n467 9.3
R1724 GND.n467 GND.n466 9.3
R1725 GND.n447 GND.n446 9.3
R1726 GND.n430 GND.n429 9.3
R1727 GND.n411 GND.n410 9.3
R1728 GND.n409 GND.n408 9.3
R1729 GND.n419 GND.n418 9.3
R1730 GND.n418 GND.n417 9.3
R1731 GND.n428 GND.n427 9.3
R1732 GND.n427 GND.n426 9.3
R1733 GND.n432 GND.n431 9.3
R1734 GND.n401 GND.n400 9.3
R1735 GND.n400 GND.n399 9.3
R1736 GND.n511 GND.n510 9.3
R1737 GND.n492 GND.n491 9.3
R1738 GND.n490 GND.n489 9.3
R1739 GND.n513 GND.n512 9.3
R1740 GND.n500 GND.n499 9.3
R1741 GND.n499 GND.n498 9.3
R1742 GND.n509 GND.n508 9.3
R1743 GND.n508 GND.n507 9.3
R1744 GND.n488 GND.n487 9.3
R1745 GND.n390 GND.n389 9.3
R1746 GND.n371 GND.n370 9.3
R1747 GND.n369 GND.n368 9.3
R1748 GND.n379 GND.n378 9.3
R1749 GND.n378 GND.n377 9.3
R1750 GND.n388 GND.n387 9.3
R1751 GND.n387 GND.n386 9.3
R1752 GND.n392 GND.n391 9.3
R1753 GND.n361 GND.n360 9.3
R1754 GND.n360 GND.n359 9.3
R1755 GND.n553 GND.n552 9.3
R1756 GND.n534 GND.n533 9.3
R1757 GND.n532 GND.n531 9.3
R1758 GND.n555 GND.n554 9.3
R1759 GND.n542 GND.n541 9.3
R1760 GND.n541 GND.n540 9.3
R1761 GND.n551 GND.n550 9.3
R1762 GND.n550 GND.n549 9.3
R1763 GND.n530 GND.n529 9.3
R1764 GND.n350 GND.n349 9.3
R1765 GND.n331 GND.n330 9.3
R1766 GND.n329 GND.n328 9.3
R1767 GND.n339 GND.n338 9.3
R1768 GND.n338 GND.n337 9.3
R1769 GND.n348 GND.n347 9.3
R1770 GND.n347 GND.n346 9.3
R1771 GND.n352 GND.n351 9.3
R1772 GND.n321 GND.n320 9.3
R1773 GND.n320 GND.n319 9.3
R1774 GND.n595 GND.n594 9.3
R1775 GND.n576 GND.n575 9.3
R1776 GND.n574 GND.n573 9.3
R1777 GND.n597 GND.n596 9.3
R1778 GND.n584 GND.n583 9.3
R1779 GND.n583 GND.n582 9.3
R1780 GND.n593 GND.n592 9.3
R1781 GND.n592 GND.n591 9.3
R1782 GND.n572 GND.n571 9.3
R1783 GND.n310 GND.n309 9.3
R1784 GND.n291 GND.n290 9.3
R1785 GND.n289 GND.n288 9.3
R1786 GND.n299 GND.n298 9.3
R1787 GND.n298 GND.n297 9.3
R1788 GND.n308 GND.n307 9.3
R1789 GND.n307 GND.n306 9.3
R1790 GND.n312 GND.n311 9.3
R1791 GND.n281 GND.n280 9.3
R1792 GND.n280 GND.n279 9.3
R1793 GND.n968 GND.n967 9.3
R1794 GND.n949 GND.n948 9.3
R1795 GND.n947 GND.n946 9.3
R1796 GND.n970 GND.n969 9.3
R1797 GND.n957 GND.n956 9.3
R1798 GND.n956 GND.n955 9.3
R1799 GND.n966 GND.n965 9.3
R1800 GND.n965 GND.n964 9.3
R1801 GND.n945 GND.n944 9.3
R1802 GND.n928 GND.n927 9.3
R1803 GND.n909 GND.n908 9.3
R1804 GND.n907 GND.n906 9.3
R1805 GND.n917 GND.n916 9.3
R1806 GND.n916 GND.n915 9.3
R1807 GND.n926 GND.n925 9.3
R1808 GND.n925 GND.n924 9.3
R1809 GND.n930 GND.n929 9.3
R1810 GND.n899 GND.n898 9.3
R1811 GND.n898 GND.n897 9.3
R1812 GND.n1009 GND.n1008 9.3
R1813 GND.n990 GND.n989 9.3
R1814 GND.n988 GND.n987 9.3
R1815 GND.n1011 GND.n1010 9.3
R1816 GND.n998 GND.n997 9.3
R1817 GND.n997 GND.n996 9.3
R1818 GND.n1007 GND.n1006 9.3
R1819 GND.n1006 GND.n1005 9.3
R1820 GND.n986 GND.n985 9.3
R1821 GND.n888 GND.n887 9.3
R1822 GND.n869 GND.n868 9.3
R1823 GND.n867 GND.n866 9.3
R1824 GND.n877 GND.n876 9.3
R1825 GND.n876 GND.n875 9.3
R1826 GND.n886 GND.n885 9.3
R1827 GND.n885 GND.n884 9.3
R1828 GND.n890 GND.n889 9.3
R1829 GND.n859 GND.n858 9.3
R1830 GND.n858 GND.n857 9.3
R1831 GND.n1051 GND.n1050 9.3
R1832 GND.n1032 GND.n1031 9.3
R1833 GND.n1030 GND.n1029 9.3
R1834 GND.n1053 GND.n1052 9.3
R1835 GND.n1040 GND.n1039 9.3
R1836 GND.n1039 GND.n1038 9.3
R1837 GND.n1049 GND.n1048 9.3
R1838 GND.n1048 GND.n1047 9.3
R1839 GND.n1028 GND.n1027 9.3
R1840 GND.n848 GND.n847 9.3
R1841 GND.n829 GND.n828 9.3
R1842 GND.n827 GND.n826 9.3
R1843 GND.n837 GND.n836 9.3
R1844 GND.n836 GND.n835 9.3
R1845 GND.n846 GND.n845 9.3
R1846 GND.n845 GND.n844 9.3
R1847 GND.n850 GND.n849 9.3
R1848 GND.n819 GND.n818 9.3
R1849 GND.n818 GND.n817 9.3
R1850 GND.n1093 GND.n1092 9.3
R1851 GND.n1074 GND.n1073 9.3
R1852 GND.n1072 GND.n1071 9.3
R1853 GND.n1095 GND.n1094 9.3
R1854 GND.n1082 GND.n1081 9.3
R1855 GND.n1081 GND.n1080 9.3
R1856 GND.n1091 GND.n1090 9.3
R1857 GND.n1090 GND.n1089 9.3
R1858 GND.n1070 GND.n1069 9.3
R1859 GND.n808 GND.n807 9.3
R1860 GND.n789 GND.n788 9.3
R1861 GND.n787 GND.n786 9.3
R1862 GND.n797 GND.n796 9.3
R1863 GND.n796 GND.n795 9.3
R1864 GND.n806 GND.n805 9.3
R1865 GND.n805 GND.n804 9.3
R1866 GND.n810 GND.n809 9.3
R1867 GND.n779 GND.n778 9.3
R1868 GND.n778 GND.n777 9.3
R1869 GND.n1135 GND.n1134 9.3
R1870 GND.n1116 GND.n1115 9.3
R1871 GND.n1114 GND.n1113 9.3
R1872 GND.n1137 GND.n1136 9.3
R1873 GND.n1124 GND.n1123 9.3
R1874 GND.n1123 GND.n1122 9.3
R1875 GND.n1133 GND.n1132 9.3
R1876 GND.n1132 GND.n1131 9.3
R1877 GND.n1112 GND.n1111 9.3
R1878 GND.n768 GND.n767 9.3
R1879 GND.n749 GND.n748 9.3
R1880 GND.n747 GND.n746 9.3
R1881 GND.n757 GND.n756 9.3
R1882 GND.n756 GND.n755 9.3
R1883 GND.n766 GND.n765 9.3
R1884 GND.n765 GND.n764 9.3
R1885 GND.n770 GND.n769 9.3
R1886 GND.n739 GND.n738 9.3
R1887 GND.n738 GND.n737 9.3
R1888 GND.n1177 GND.n1176 9.3
R1889 GND.n1158 GND.n1157 9.3
R1890 GND.n1156 GND.n1155 9.3
R1891 GND.n1179 GND.n1178 9.3
R1892 GND.n1166 GND.n1165 9.3
R1893 GND.n1165 GND.n1164 9.3
R1894 GND.n1175 GND.n1174 9.3
R1895 GND.n1174 GND.n1173 9.3
R1896 GND.n1154 GND.n1153 9.3
R1897 GND.n728 GND.n727 9.3
R1898 GND.n709 GND.n708 9.3
R1899 GND.n707 GND.n706 9.3
R1900 GND.n717 GND.n716 9.3
R1901 GND.n716 GND.n715 9.3
R1902 GND.n726 GND.n725 9.3
R1903 GND.n725 GND.n724 9.3
R1904 GND.n730 GND.n729 9.3
R1905 GND.n699 GND.n698 9.3
R1906 GND.n698 GND.n697 9.3
R1907 GND.n1219 GND.n1218 9.3
R1908 GND.n1200 GND.n1199 9.3
R1909 GND.n1198 GND.n1197 9.3
R1910 GND.n1221 GND.n1220 9.3
R1911 GND.n1208 GND.n1207 9.3
R1912 GND.n1207 GND.n1206 9.3
R1913 GND.n1217 GND.n1216 9.3
R1914 GND.n1216 GND.n1215 9.3
R1915 GND.n1196 GND.n1195 9.3
R1916 GND.n688 GND.n687 9.3
R1917 GND.n669 GND.n668 9.3
R1918 GND.n667 GND.n666 9.3
R1919 GND.n677 GND.n676 9.3
R1920 GND.n676 GND.n675 9.3
R1921 GND.n686 GND.n685 9.3
R1922 GND.n685 GND.n684 9.3
R1923 GND.n690 GND.n689 9.3
R1924 GND.n659 GND.n658 9.3
R1925 GND.n658 GND.n657 9.3
R1926 GND.n1261 GND.n1260 9.3
R1927 GND.n1242 GND.n1241 9.3
R1928 GND.n1240 GND.n1239 9.3
R1929 GND.n1263 GND.n1262 9.3
R1930 GND.n1250 GND.n1249 9.3
R1931 GND.n1249 GND.n1248 9.3
R1932 GND.n1259 GND.n1258 9.3
R1933 GND.n1258 GND.n1257 9.3
R1934 GND.n1238 GND.n1237 9.3
R1935 GND.n648 GND.n647 9.3
R1936 GND.n629 GND.n628 9.3
R1937 GND.n627 GND.n626 9.3
R1938 GND.n637 GND.n636 9.3
R1939 GND.n636 GND.n635 9.3
R1940 GND.n646 GND.n645 9.3
R1941 GND.n645 GND.n644 9.3
R1942 GND.n650 GND.n649 9.3
R1943 GND.n619 GND.n618 9.3
R1944 GND.n618 GND.n617 9.3
R1945 GND.n1954 GND.n1953 9.3
R1946 GND.n1935 GND.n1934 9.3
R1947 GND.n1933 GND.n1932 9.3
R1948 GND.n1956 GND.n1955 9.3
R1949 GND.n1943 GND.n1942 9.3
R1950 GND.n1942 GND.n1941 9.3
R1951 GND.n1952 GND.n1951 9.3
R1952 GND.n1951 GND.n1950 9.3
R1953 GND.n1931 GND.n1930 9.3
R1954 GND.n1914 GND.n1913 9.3
R1955 GND.n1895 GND.n1894 9.3
R1956 GND.n1893 GND.n1892 9.3
R1957 GND.n1903 GND.n1902 9.3
R1958 GND.n1902 GND.n1901 9.3
R1959 GND.n1912 GND.n1911 9.3
R1960 GND.n1911 GND.n1910 9.3
R1961 GND.n1916 GND.n1915 9.3
R1962 GND.n1885 GND.n1884 9.3
R1963 GND.n1884 GND.n1883 9.3
R1964 GND.n1995 GND.n1994 9.3
R1965 GND.n1976 GND.n1975 9.3
R1966 GND.n1974 GND.n1973 9.3
R1967 GND.n1997 GND.n1996 9.3
R1968 GND.n1984 GND.n1983 9.3
R1969 GND.n1983 GND.n1982 9.3
R1970 GND.n1993 GND.n1992 9.3
R1971 GND.n1992 GND.n1991 9.3
R1972 GND.n1972 GND.n1971 9.3
R1973 GND.n1874 GND.n1873 9.3
R1974 GND.n1855 GND.n1854 9.3
R1975 GND.n1853 GND.n1852 9.3
R1976 GND.n1863 GND.n1862 9.3
R1977 GND.n1862 GND.n1861 9.3
R1978 GND.n1872 GND.n1871 9.3
R1979 GND.n1871 GND.n1870 9.3
R1980 GND.n1876 GND.n1875 9.3
R1981 GND.n1845 GND.n1844 9.3
R1982 GND.n1844 GND.n1843 9.3
R1983 GND.n2037 GND.n2036 9.3
R1984 GND.n2018 GND.n2017 9.3
R1985 GND.n2016 GND.n2015 9.3
R1986 GND.n2039 GND.n2038 9.3
R1987 GND.n2026 GND.n2025 9.3
R1988 GND.n2025 GND.n2024 9.3
R1989 GND.n2035 GND.n2034 9.3
R1990 GND.n2034 GND.n2033 9.3
R1991 GND.n2014 GND.n2013 9.3
R1992 GND.n1834 GND.n1833 9.3
R1993 GND.n1815 GND.n1814 9.3
R1994 GND.n1813 GND.n1812 9.3
R1995 GND.n1823 GND.n1822 9.3
R1996 GND.n1822 GND.n1821 9.3
R1997 GND.n1832 GND.n1831 9.3
R1998 GND.n1831 GND.n1830 9.3
R1999 GND.n1836 GND.n1835 9.3
R2000 GND.n1805 GND.n1804 9.3
R2001 GND.n1804 GND.n1803 9.3
R2002 GND.n2079 GND.n2078 9.3
R2003 GND.n2060 GND.n2059 9.3
R2004 GND.n2058 GND.n2057 9.3
R2005 GND.n2081 GND.n2080 9.3
R2006 GND.n2068 GND.n2067 9.3
R2007 GND.n2067 GND.n2066 9.3
R2008 GND.n2077 GND.n2076 9.3
R2009 GND.n2076 GND.n2075 9.3
R2010 GND.n2056 GND.n2055 9.3
R2011 GND.n1794 GND.n1793 9.3
R2012 GND.n1775 GND.n1774 9.3
R2013 GND.n1773 GND.n1772 9.3
R2014 GND.n1783 GND.n1782 9.3
R2015 GND.n1782 GND.n1781 9.3
R2016 GND.n1792 GND.n1791 9.3
R2017 GND.n1791 GND.n1790 9.3
R2018 GND.n1796 GND.n1795 9.3
R2019 GND.n1765 GND.n1764 9.3
R2020 GND.n1764 GND.n1763 9.3
R2021 GND.n2121 GND.n2120 9.3
R2022 GND.n2102 GND.n2101 9.3
R2023 GND.n2100 GND.n2099 9.3
R2024 GND.n2123 GND.n2122 9.3
R2025 GND.n2110 GND.n2109 9.3
R2026 GND.n2109 GND.n2108 9.3
R2027 GND.n2119 GND.n2118 9.3
R2028 GND.n2118 GND.n2117 9.3
R2029 GND.n2098 GND.n2097 9.3
R2030 GND.n1754 GND.n1753 9.3
R2031 GND.n1735 GND.n1734 9.3
R2032 GND.n1733 GND.n1732 9.3
R2033 GND.n1743 GND.n1742 9.3
R2034 GND.n1742 GND.n1741 9.3
R2035 GND.n1752 GND.n1751 9.3
R2036 GND.n1751 GND.n1750 9.3
R2037 GND.n1756 GND.n1755 9.3
R2038 GND.n1725 GND.n1724 9.3
R2039 GND.n1724 GND.n1723 9.3
R2040 GND.n2163 GND.n2162 9.3
R2041 GND.n2144 GND.n2143 9.3
R2042 GND.n2142 GND.n2141 9.3
R2043 GND.n2165 GND.n2164 9.3
R2044 GND.n2152 GND.n2151 9.3
R2045 GND.n2151 GND.n2150 9.3
R2046 GND.n2161 GND.n2160 9.3
R2047 GND.n2160 GND.n2159 9.3
R2048 GND.n2140 GND.n2139 9.3
R2049 GND.n1714 GND.n1713 9.3
R2050 GND.n1695 GND.n1694 9.3
R2051 GND.n1693 GND.n1692 9.3
R2052 GND.n1703 GND.n1702 9.3
R2053 GND.n1702 GND.n1701 9.3
R2054 GND.n1712 GND.n1711 9.3
R2055 GND.n1711 GND.n1710 9.3
R2056 GND.n1716 GND.n1715 9.3
R2057 GND.n1685 GND.n1684 9.3
R2058 GND.n1684 GND.n1683 9.3
R2059 GND.n2205 GND.n2204 9.3
R2060 GND.n2186 GND.n2185 9.3
R2061 GND.n2184 GND.n2183 9.3
R2062 GND.n2207 GND.n2206 9.3
R2063 GND.n2194 GND.n2193 9.3
R2064 GND.n2193 GND.n2192 9.3
R2065 GND.n2203 GND.n2202 9.3
R2066 GND.n2202 GND.n2201 9.3
R2067 GND.n2182 GND.n2181 9.3
R2068 GND.n1674 GND.n1673 9.3
R2069 GND.n1655 GND.n1654 9.3
R2070 GND.n1653 GND.n1652 9.3
R2071 GND.n1663 GND.n1662 9.3
R2072 GND.n1662 GND.n1661 9.3
R2073 GND.n1672 GND.n1671 9.3
R2074 GND.n1671 GND.n1670 9.3
R2075 GND.n1676 GND.n1675 9.3
R2076 GND.n1645 GND.n1644 9.3
R2077 GND.n1644 GND.n1643 9.3
R2078 GND.n2247 GND.n2246 9.3
R2079 GND.n2228 GND.n2227 9.3
R2080 GND.n2226 GND.n2225 9.3
R2081 GND.n2249 GND.n2248 9.3
R2082 GND.n2236 GND.n2235 9.3
R2083 GND.n2235 GND.n2234 9.3
R2084 GND.n2245 GND.n2244 9.3
R2085 GND.n2244 GND.n2243 9.3
R2086 GND.n2224 GND.n2223 9.3
R2087 GND.n1634 GND.n1633 9.3
R2088 GND.n1615 GND.n1614 9.3
R2089 GND.n1613 GND.n1612 9.3
R2090 GND.n1623 GND.n1622 9.3
R2091 GND.n1622 GND.n1621 9.3
R2092 GND.n1632 GND.n1631 9.3
R2093 GND.n1631 GND.n1630 9.3
R2094 GND.n1636 GND.n1635 9.3
R2095 GND.n1605 GND.n1604 9.3
R2096 GND.n1604 GND.n1603 9.3
R2097 GND.n2289 GND.n2288 9.3
R2098 GND.n2270 GND.n2269 9.3
R2099 GND.n2268 GND.n2267 9.3
R2100 GND.n2291 GND.n2290 9.3
R2101 GND.n2278 GND.n2277 9.3
R2102 GND.n2277 GND.n2276 9.3
R2103 GND.n2287 GND.n2286 9.3
R2104 GND.n2286 GND.n2285 9.3
R2105 GND.n2266 GND.n2265 9.3
R2106 GND.n1594 GND.n1593 9.3
R2107 GND.n1575 GND.n1574 9.3
R2108 GND.n1573 GND.n1572 9.3
R2109 GND.n1583 GND.n1582 9.3
R2110 GND.n1582 GND.n1581 9.3
R2111 GND.n1592 GND.n1591 9.3
R2112 GND.n1591 GND.n1590 9.3
R2113 GND.n1596 GND.n1595 9.3
R2114 GND.n1565 GND.n1564 9.3
R2115 GND.n1564 GND.n1563 9.3
R2116 GND.n2331 GND.n2330 9.3
R2117 GND.n2312 GND.n2311 9.3
R2118 GND.n2310 GND.n2309 9.3
R2119 GND.n2333 GND.n2332 9.3
R2120 GND.n2320 GND.n2319 9.3
R2121 GND.n2319 GND.n2318 9.3
R2122 GND.n2329 GND.n2328 9.3
R2123 GND.n2328 GND.n2327 9.3
R2124 GND.n2308 GND.n2307 9.3
R2125 GND.n1554 GND.n1553 9.3
R2126 GND.n1535 GND.n1534 9.3
R2127 GND.n1533 GND.n1532 9.3
R2128 GND.n1543 GND.n1542 9.3
R2129 GND.n1542 GND.n1541 9.3
R2130 GND.n1552 GND.n1551 9.3
R2131 GND.n1551 GND.n1550 9.3
R2132 GND.n1556 GND.n1555 9.3
R2133 GND.n1525 GND.n1524 9.3
R2134 GND.n1524 GND.n1523 9.3
R2135 GND.n2373 GND.n2372 9.3
R2136 GND.n2354 GND.n2353 9.3
R2137 GND.n2352 GND.n2351 9.3
R2138 GND.n2375 GND.n2374 9.3
R2139 GND.n2362 GND.n2361 9.3
R2140 GND.n2361 GND.n2360 9.3
R2141 GND.n2371 GND.n2370 9.3
R2142 GND.n2370 GND.n2369 9.3
R2143 GND.n2350 GND.n2349 9.3
R2144 GND.n1514 GND.n1513 9.3
R2145 GND.n1495 GND.n1494 9.3
R2146 GND.n1493 GND.n1492 9.3
R2147 GND.n1503 GND.n1502 9.3
R2148 GND.n1502 GND.n1501 9.3
R2149 GND.n1512 GND.n1511 9.3
R2150 GND.n1511 GND.n1510 9.3
R2151 GND.n1516 GND.n1515 9.3
R2152 GND.n1485 GND.n1484 9.3
R2153 GND.n1484 GND.n1483 9.3
R2154 GND.n2415 GND.n2414 9.3
R2155 GND.n2396 GND.n2395 9.3
R2156 GND.n2394 GND.n2393 9.3
R2157 GND.n2417 GND.n2416 9.3
R2158 GND.n2404 GND.n2403 9.3
R2159 GND.n2403 GND.n2402 9.3
R2160 GND.n2413 GND.n2412 9.3
R2161 GND.n2412 GND.n2411 9.3
R2162 GND.n2392 GND.n2391 9.3
R2163 GND.n1474 GND.n1473 9.3
R2164 GND.n1455 GND.n1454 9.3
R2165 GND.n1453 GND.n1452 9.3
R2166 GND.n1463 GND.n1462 9.3
R2167 GND.n1462 GND.n1461 9.3
R2168 GND.n1472 GND.n1471 9.3
R2169 GND.n1471 GND.n1470 9.3
R2170 GND.n1476 GND.n1475 9.3
R2171 GND.n1445 GND.n1444 9.3
R2172 GND.n1444 GND.n1443 9.3
R2173 GND.n2457 GND.n2456 9.3
R2174 GND.n2438 GND.n2437 9.3
R2175 GND.n2436 GND.n2435 9.3
R2176 GND.n2459 GND.n2458 9.3
R2177 GND.n2446 GND.n2445 9.3
R2178 GND.n2445 GND.n2444 9.3
R2179 GND.n2455 GND.n2454 9.3
R2180 GND.n2454 GND.n2453 9.3
R2181 GND.n2434 GND.n2433 9.3
R2182 GND.n1434 GND.n1433 9.3
R2183 GND.n1415 GND.n1414 9.3
R2184 GND.n1413 GND.n1412 9.3
R2185 GND.n1423 GND.n1422 9.3
R2186 GND.n1422 GND.n1421 9.3
R2187 GND.n1432 GND.n1431 9.3
R2188 GND.n1431 GND.n1430 9.3
R2189 GND.n1436 GND.n1435 9.3
R2190 GND.n1405 GND.n1404 9.3
R2191 GND.n1404 GND.n1403 9.3
R2192 GND.n2499 GND.n2498 9.3
R2193 GND.n2480 GND.n2479 9.3
R2194 GND.n2478 GND.n2477 9.3
R2195 GND.n2501 GND.n2500 9.3
R2196 GND.n2488 GND.n2487 9.3
R2197 GND.n2487 GND.n2486 9.3
R2198 GND.n2497 GND.n2496 9.3
R2199 GND.n2496 GND.n2495 9.3
R2200 GND.n2476 GND.n2475 9.3
R2201 GND.n1394 GND.n1393 9.3
R2202 GND.n1375 GND.n1374 9.3
R2203 GND.n1373 GND.n1372 9.3
R2204 GND.n1383 GND.n1382 9.3
R2205 GND.n1382 GND.n1381 9.3
R2206 GND.n1392 GND.n1391 9.3
R2207 GND.n1391 GND.n1390 9.3
R2208 GND.n1396 GND.n1395 9.3
R2209 GND.n1365 GND.n1364 9.3
R2210 GND.n1364 GND.n1363 9.3
R2211 GND.n2541 GND.n2540 9.3
R2212 GND.n2522 GND.n2521 9.3
R2213 GND.n2520 GND.n2519 9.3
R2214 GND.n2543 GND.n2542 9.3
R2215 GND.n2530 GND.n2529 9.3
R2216 GND.n2529 GND.n2528 9.3
R2217 GND.n2539 GND.n2538 9.3
R2218 GND.n2538 GND.n2537 9.3
R2219 GND.n2518 GND.n2517 9.3
R2220 GND.n1354 GND.n1353 9.3
R2221 GND.n1335 GND.n1334 9.3
R2222 GND.n1333 GND.n1332 9.3
R2223 GND.n1343 GND.n1342 9.3
R2224 GND.n1342 GND.n1341 9.3
R2225 GND.n1352 GND.n1351 9.3
R2226 GND.n1351 GND.n1350 9.3
R2227 GND.n1356 GND.n1355 9.3
R2228 GND.n1325 GND.n1324 9.3
R2229 GND.n1324 GND.n1323 9.3
R2230 GND.n2583 GND.n2582 9.3
R2231 GND.n2564 GND.n2563 9.3
R2232 GND.n2562 GND.n2561 9.3
R2233 GND.n2585 GND.n2584 9.3
R2234 GND.n2572 GND.n2571 9.3
R2235 GND.n2571 GND.n2570 9.3
R2236 GND.n2581 GND.n2580 9.3
R2237 GND.n2580 GND.n2579 9.3
R2238 GND.n2560 GND.n2559 9.3
R2239 GND.n1314 GND.n1313 9.3
R2240 GND.n1295 GND.n1294 9.3
R2241 GND.n1293 GND.n1292 9.3
R2242 GND.n1303 GND.n1302 9.3
R2243 GND.n1302 GND.n1301 9.3
R2244 GND.n1312 GND.n1311 9.3
R2245 GND.n1311 GND.n1310 9.3
R2246 GND.n1316 GND.n1315 9.3
R2247 GND.n1285 GND.n1284 9.3
R2248 GND.n1284 GND.n1283 9.3
R2249 GND.n3276 GND.n3275 9.3
R2250 GND.n3257 GND.n3256 9.3
R2251 GND.n3255 GND.n3254 9.3
R2252 GND.n3278 GND.n3277 9.3
R2253 GND.n3265 GND.n3264 9.3
R2254 GND.n3264 GND.n3263 9.3
R2255 GND.n3274 GND.n3273 9.3
R2256 GND.n3273 GND.n3272 9.3
R2257 GND.n3253 GND.n3252 9.3
R2258 GND.n3236 GND.n3235 9.3
R2259 GND.n3217 GND.n3216 9.3
R2260 GND.n3215 GND.n3214 9.3
R2261 GND.n3225 GND.n3224 9.3
R2262 GND.n3224 GND.n3223 9.3
R2263 GND.n3234 GND.n3233 9.3
R2264 GND.n3233 GND.n3232 9.3
R2265 GND.n3238 GND.n3237 9.3
R2266 GND.n3207 GND.n3206 9.3
R2267 GND.n3206 GND.n3205 9.3
R2268 GND.n3317 GND.n3316 9.3
R2269 GND.n3298 GND.n3297 9.3
R2270 GND.n3296 GND.n3295 9.3
R2271 GND.n3319 GND.n3318 9.3
R2272 GND.n3306 GND.n3305 9.3
R2273 GND.n3305 GND.n3304 9.3
R2274 GND.n3315 GND.n3314 9.3
R2275 GND.n3314 GND.n3313 9.3
R2276 GND.n3294 GND.n3293 9.3
R2277 GND.n3196 GND.n3195 9.3
R2278 GND.n3177 GND.n3176 9.3
R2279 GND.n3175 GND.n3174 9.3
R2280 GND.n3185 GND.n3184 9.3
R2281 GND.n3184 GND.n3183 9.3
R2282 GND.n3194 GND.n3193 9.3
R2283 GND.n3193 GND.n3192 9.3
R2284 GND.n3198 GND.n3197 9.3
R2285 GND.n3167 GND.n3166 9.3
R2286 GND.n3166 GND.n3165 9.3
R2287 GND.n3359 GND.n3358 9.3
R2288 GND.n3340 GND.n3339 9.3
R2289 GND.n3338 GND.n3337 9.3
R2290 GND.n3361 GND.n3360 9.3
R2291 GND.n3348 GND.n3347 9.3
R2292 GND.n3347 GND.n3346 9.3
R2293 GND.n3357 GND.n3356 9.3
R2294 GND.n3356 GND.n3355 9.3
R2295 GND.n3336 GND.n3335 9.3
R2296 GND.n3156 GND.n3155 9.3
R2297 GND.n3137 GND.n3136 9.3
R2298 GND.n3135 GND.n3134 9.3
R2299 GND.n3145 GND.n3144 9.3
R2300 GND.n3144 GND.n3143 9.3
R2301 GND.n3154 GND.n3153 9.3
R2302 GND.n3153 GND.n3152 9.3
R2303 GND.n3158 GND.n3157 9.3
R2304 GND.n3127 GND.n3126 9.3
R2305 GND.n3126 GND.n3125 9.3
R2306 GND.n3401 GND.n3400 9.3
R2307 GND.n3382 GND.n3381 9.3
R2308 GND.n3380 GND.n3379 9.3
R2309 GND.n3403 GND.n3402 9.3
R2310 GND.n3390 GND.n3389 9.3
R2311 GND.n3389 GND.n3388 9.3
R2312 GND.n3399 GND.n3398 9.3
R2313 GND.n3398 GND.n3397 9.3
R2314 GND.n3378 GND.n3377 9.3
R2315 GND.n3116 GND.n3115 9.3
R2316 GND.n3097 GND.n3096 9.3
R2317 GND.n3095 GND.n3094 9.3
R2318 GND.n3105 GND.n3104 9.3
R2319 GND.n3104 GND.n3103 9.3
R2320 GND.n3114 GND.n3113 9.3
R2321 GND.n3113 GND.n3112 9.3
R2322 GND.n3118 GND.n3117 9.3
R2323 GND.n3087 GND.n3086 9.3
R2324 GND.n3086 GND.n3085 9.3
R2325 GND.n3443 GND.n3442 9.3
R2326 GND.n3424 GND.n3423 9.3
R2327 GND.n3422 GND.n3421 9.3
R2328 GND.n3445 GND.n3444 9.3
R2329 GND.n3432 GND.n3431 9.3
R2330 GND.n3431 GND.n3430 9.3
R2331 GND.n3441 GND.n3440 9.3
R2332 GND.n3440 GND.n3439 9.3
R2333 GND.n3420 GND.n3419 9.3
R2334 GND.n3076 GND.n3075 9.3
R2335 GND.n3057 GND.n3056 9.3
R2336 GND.n3055 GND.n3054 9.3
R2337 GND.n3065 GND.n3064 9.3
R2338 GND.n3064 GND.n3063 9.3
R2339 GND.n3074 GND.n3073 9.3
R2340 GND.n3073 GND.n3072 9.3
R2341 GND.n3078 GND.n3077 9.3
R2342 GND.n3047 GND.n3046 9.3
R2343 GND.n3046 GND.n3045 9.3
R2344 GND.n3485 GND.n3484 9.3
R2345 GND.n3466 GND.n3465 9.3
R2346 GND.n3464 GND.n3463 9.3
R2347 GND.n3487 GND.n3486 9.3
R2348 GND.n3474 GND.n3473 9.3
R2349 GND.n3473 GND.n3472 9.3
R2350 GND.n3483 GND.n3482 9.3
R2351 GND.n3482 GND.n3481 9.3
R2352 GND.n3462 GND.n3461 9.3
R2353 GND.n3036 GND.n3035 9.3
R2354 GND.n3017 GND.n3016 9.3
R2355 GND.n3015 GND.n3014 9.3
R2356 GND.n3025 GND.n3024 9.3
R2357 GND.n3024 GND.n3023 9.3
R2358 GND.n3034 GND.n3033 9.3
R2359 GND.n3033 GND.n3032 9.3
R2360 GND.n3038 GND.n3037 9.3
R2361 GND.n3007 GND.n3006 9.3
R2362 GND.n3006 GND.n3005 9.3
R2363 GND.n3527 GND.n3526 9.3
R2364 GND.n3508 GND.n3507 9.3
R2365 GND.n3506 GND.n3505 9.3
R2366 GND.n3529 GND.n3528 9.3
R2367 GND.n3516 GND.n3515 9.3
R2368 GND.n3515 GND.n3514 9.3
R2369 GND.n3525 GND.n3524 9.3
R2370 GND.n3524 GND.n3523 9.3
R2371 GND.n3504 GND.n3503 9.3
R2372 GND.n2996 GND.n2995 9.3
R2373 GND.n2977 GND.n2976 9.3
R2374 GND.n2975 GND.n2974 9.3
R2375 GND.n2985 GND.n2984 9.3
R2376 GND.n2984 GND.n2983 9.3
R2377 GND.n2994 GND.n2993 9.3
R2378 GND.n2993 GND.n2992 9.3
R2379 GND.n2998 GND.n2997 9.3
R2380 GND.n2967 GND.n2966 9.3
R2381 GND.n2966 GND.n2965 9.3
R2382 GND.n3569 GND.n3568 9.3
R2383 GND.n3550 GND.n3549 9.3
R2384 GND.n3548 GND.n3547 9.3
R2385 GND.n3571 GND.n3570 9.3
R2386 GND.n3558 GND.n3557 9.3
R2387 GND.n3557 GND.n3556 9.3
R2388 GND.n3567 GND.n3566 9.3
R2389 GND.n3566 GND.n3565 9.3
R2390 GND.n3546 GND.n3545 9.3
R2391 GND.n2956 GND.n2955 9.3
R2392 GND.n2937 GND.n2936 9.3
R2393 GND.n2935 GND.n2934 9.3
R2394 GND.n2945 GND.n2944 9.3
R2395 GND.n2944 GND.n2943 9.3
R2396 GND.n2954 GND.n2953 9.3
R2397 GND.n2953 GND.n2952 9.3
R2398 GND.n2958 GND.n2957 9.3
R2399 GND.n2927 GND.n2926 9.3
R2400 GND.n2926 GND.n2925 9.3
R2401 GND.n3931 GND.n3930 9.3
R2402 GND.n3912 GND.n3911 9.3
R2403 GND.n3910 GND.n3909 9.3
R2404 GND.n3933 GND.n3932 9.3
R2405 GND.n3920 GND.n3919 9.3
R2406 GND.n3919 GND.n3918 9.3
R2407 GND.n3929 GND.n3928 9.3
R2408 GND.n3928 GND.n3927 9.3
R2409 GND.n3908 GND.n3907 9.3
R2410 GND.n3891 GND.n3890 9.3
R2411 GND.n3872 GND.n3871 9.3
R2412 GND.n3870 GND.n3869 9.3
R2413 GND.n3880 GND.n3879 9.3
R2414 GND.n3879 GND.n3878 9.3
R2415 GND.n3889 GND.n3888 9.3
R2416 GND.n3888 GND.n3887 9.3
R2417 GND.n3893 GND.n3892 9.3
R2418 GND.n3862 GND.n3861 9.3
R2419 GND.n3861 GND.n3860 9.3
R2420 GND.n3972 GND.n3971 9.3
R2421 GND.n3953 GND.n3952 9.3
R2422 GND.n3951 GND.n3950 9.3
R2423 GND.n3974 GND.n3973 9.3
R2424 GND.n3961 GND.n3960 9.3
R2425 GND.n3960 GND.n3959 9.3
R2426 GND.n3970 GND.n3969 9.3
R2427 GND.n3969 GND.n3968 9.3
R2428 GND.n3949 GND.n3948 9.3
R2429 GND.n3851 GND.n3850 9.3
R2430 GND.n3832 GND.n3831 9.3
R2431 GND.n3830 GND.n3829 9.3
R2432 GND.n3840 GND.n3839 9.3
R2433 GND.n3839 GND.n3838 9.3
R2434 GND.n3849 GND.n3848 9.3
R2435 GND.n3848 GND.n3847 9.3
R2436 GND.n3853 GND.n3852 9.3
R2437 GND.n3822 GND.n3821 9.3
R2438 GND.n3821 GND.n3820 9.3
R2439 GND.n4014 GND.n4013 9.3
R2440 GND.n3995 GND.n3994 9.3
R2441 GND.n3993 GND.n3992 9.3
R2442 GND.n4016 GND.n4015 9.3
R2443 GND.n4003 GND.n4002 9.3
R2444 GND.n4002 GND.n4001 9.3
R2445 GND.n4012 GND.n4011 9.3
R2446 GND.n4011 GND.n4010 9.3
R2447 GND.n3991 GND.n3990 9.3
R2448 GND.n3811 GND.n3810 9.3
R2449 GND.n3792 GND.n3791 9.3
R2450 GND.n3790 GND.n3789 9.3
R2451 GND.n3800 GND.n3799 9.3
R2452 GND.n3799 GND.n3798 9.3
R2453 GND.n3809 GND.n3808 9.3
R2454 GND.n3808 GND.n3807 9.3
R2455 GND.n3813 GND.n3812 9.3
R2456 GND.n3782 GND.n3781 9.3
R2457 GND.n3781 GND.n3780 9.3
R2458 GND.n4056 GND.n4055 9.3
R2459 GND.n4037 GND.n4036 9.3
R2460 GND.n4035 GND.n4034 9.3
R2461 GND.n4058 GND.n4057 9.3
R2462 GND.n4045 GND.n4044 9.3
R2463 GND.n4044 GND.n4043 9.3
R2464 GND.n4054 GND.n4053 9.3
R2465 GND.n4053 GND.n4052 9.3
R2466 GND.n4033 GND.n4032 9.3
R2467 GND.n3771 GND.n3770 9.3
R2468 GND.n3752 GND.n3751 9.3
R2469 GND.n3750 GND.n3749 9.3
R2470 GND.n3760 GND.n3759 9.3
R2471 GND.n3759 GND.n3758 9.3
R2472 GND.n3769 GND.n3768 9.3
R2473 GND.n3768 GND.n3767 9.3
R2474 GND.n3773 GND.n3772 9.3
R2475 GND.n3742 GND.n3741 9.3
R2476 GND.n3741 GND.n3740 9.3
R2477 GND.n4098 GND.n4097 9.3
R2478 GND.n4079 GND.n4078 9.3
R2479 GND.n4077 GND.n4076 9.3
R2480 GND.n4100 GND.n4099 9.3
R2481 GND.n4087 GND.n4086 9.3
R2482 GND.n4086 GND.n4085 9.3
R2483 GND.n4096 GND.n4095 9.3
R2484 GND.n4095 GND.n4094 9.3
R2485 GND.n4075 GND.n4074 9.3
R2486 GND.n3731 GND.n3730 9.3
R2487 GND.n3712 GND.n3711 9.3
R2488 GND.n3710 GND.n3709 9.3
R2489 GND.n3720 GND.n3719 9.3
R2490 GND.n3719 GND.n3718 9.3
R2491 GND.n3729 GND.n3728 9.3
R2492 GND.n3728 GND.n3727 9.3
R2493 GND.n3733 GND.n3732 9.3
R2494 GND.n3702 GND.n3701 9.3
R2495 GND.n3701 GND.n3700 9.3
R2496 GND.n4140 GND.n4139 9.3
R2497 GND.n4121 GND.n4120 9.3
R2498 GND.n4119 GND.n4118 9.3
R2499 GND.n4142 GND.n4141 9.3
R2500 GND.n4129 GND.n4128 9.3
R2501 GND.n4128 GND.n4127 9.3
R2502 GND.n4138 GND.n4137 9.3
R2503 GND.n4137 GND.n4136 9.3
R2504 GND.n4117 GND.n4116 9.3
R2505 GND.n3691 GND.n3690 9.3
R2506 GND.n3672 GND.n3671 9.3
R2507 GND.n3670 GND.n3669 9.3
R2508 GND.n3680 GND.n3679 9.3
R2509 GND.n3679 GND.n3678 9.3
R2510 GND.n3689 GND.n3688 9.3
R2511 GND.n3688 GND.n3687 9.3
R2512 GND.n3693 GND.n3692 9.3
R2513 GND.n3662 GND.n3661 9.3
R2514 GND.n3661 GND.n3660 9.3
R2515 GND.n4182 GND.n4181 9.3
R2516 GND.n4163 GND.n4162 9.3
R2517 GND.n4161 GND.n4160 9.3
R2518 GND.n4184 GND.n4183 9.3
R2519 GND.n4171 GND.n4170 9.3
R2520 GND.n4170 GND.n4169 9.3
R2521 GND.n4180 GND.n4179 9.3
R2522 GND.n4179 GND.n4178 9.3
R2523 GND.n4159 GND.n4158 9.3
R2524 GND.n3651 GND.n3650 9.3
R2525 GND.n3632 GND.n3631 9.3
R2526 GND.n3630 GND.n3629 9.3
R2527 GND.n3640 GND.n3639 9.3
R2528 GND.n3639 GND.n3638 9.3
R2529 GND.n3649 GND.n3648 9.3
R2530 GND.n3648 GND.n3647 9.3
R2531 GND.n3653 GND.n3652 9.3
R2532 GND.n3622 GND.n3621 9.3
R2533 GND.n3621 GND.n3620 9.3
R2534 GND.n4224 GND.n4223 9.3
R2535 GND.n4205 GND.n4204 9.3
R2536 GND.n4203 GND.n4202 9.3
R2537 GND.n4226 GND.n4225 9.3
R2538 GND.n4213 GND.n4212 9.3
R2539 GND.n4212 GND.n4211 9.3
R2540 GND.n4222 GND.n4221 9.3
R2541 GND.n4221 GND.n4220 9.3
R2542 GND.n4201 GND.n4200 9.3
R2543 GND.n3611 GND.n3610 9.3
R2544 GND.n3592 GND.n3591 9.3
R2545 GND.n3590 GND.n3589 9.3
R2546 GND.n3600 GND.n3599 9.3
R2547 GND.n3599 GND.n3598 9.3
R2548 GND.n3609 GND.n3608 9.3
R2549 GND.n3608 GND.n3607 9.3
R2550 GND.n3613 GND.n3612 9.3
R2551 GND.n3582 GND.n3581 9.3
R2552 GND.n3581 GND.n3580 9.3
R2553 GND.n4587 GND.n4586 9.3
R2554 GND.n4568 GND.n4567 9.3
R2555 GND.n4566 GND.n4565 9.3
R2556 GND.n4589 GND.n4588 9.3
R2557 GND.n4576 GND.n4575 9.3
R2558 GND.n4575 GND.n4574 9.3
R2559 GND.n4585 GND.n4584 9.3
R2560 GND.n4584 GND.n4583 9.3
R2561 GND.n4564 GND.n4563 9.3
R2562 GND.n4547 GND.n4546 9.3
R2563 GND.n4528 GND.n4527 9.3
R2564 GND.n4526 GND.n4525 9.3
R2565 GND.n4536 GND.n4535 9.3
R2566 GND.n4535 GND.n4534 9.3
R2567 GND.n4545 GND.n4544 9.3
R2568 GND.n4544 GND.n4543 9.3
R2569 GND.n4549 GND.n4548 9.3
R2570 GND.n4518 GND.n4517 9.3
R2571 GND.n4517 GND.n4516 9.3
R2572 GND.n4628 GND.n4627 9.3
R2573 GND.n4609 GND.n4608 9.3
R2574 GND.n4607 GND.n4606 9.3
R2575 GND.n4630 GND.n4629 9.3
R2576 GND.n4617 GND.n4616 9.3
R2577 GND.n4616 GND.n4615 9.3
R2578 GND.n4626 GND.n4625 9.3
R2579 GND.n4625 GND.n4624 9.3
R2580 GND.n4605 GND.n4604 9.3
R2581 GND.n4507 GND.n4506 9.3
R2582 GND.n4488 GND.n4487 9.3
R2583 GND.n4486 GND.n4485 9.3
R2584 GND.n4496 GND.n4495 9.3
R2585 GND.n4495 GND.n4494 9.3
R2586 GND.n4505 GND.n4504 9.3
R2587 GND.n4504 GND.n4503 9.3
R2588 GND.n4509 GND.n4508 9.3
R2589 GND.n4478 GND.n4477 9.3
R2590 GND.n4477 GND.n4476 9.3
R2591 GND.n4670 GND.n4669 9.3
R2592 GND.n4651 GND.n4650 9.3
R2593 GND.n4649 GND.n4648 9.3
R2594 GND.n4672 GND.n4671 9.3
R2595 GND.n4659 GND.n4658 9.3
R2596 GND.n4658 GND.n4657 9.3
R2597 GND.n4668 GND.n4667 9.3
R2598 GND.n4667 GND.n4666 9.3
R2599 GND.n4647 GND.n4646 9.3
R2600 GND.n4467 GND.n4466 9.3
R2601 GND.n4448 GND.n4447 9.3
R2602 GND.n4446 GND.n4445 9.3
R2603 GND.n4456 GND.n4455 9.3
R2604 GND.n4455 GND.n4454 9.3
R2605 GND.n4465 GND.n4464 9.3
R2606 GND.n4464 GND.n4463 9.3
R2607 GND.n4469 GND.n4468 9.3
R2608 GND.n4438 GND.n4437 9.3
R2609 GND.n4437 GND.n4436 9.3
R2610 GND.n4712 GND.n4711 9.3
R2611 GND.n4693 GND.n4692 9.3
R2612 GND.n4691 GND.n4690 9.3
R2613 GND.n4714 GND.n4713 9.3
R2614 GND.n4701 GND.n4700 9.3
R2615 GND.n4700 GND.n4699 9.3
R2616 GND.n4710 GND.n4709 9.3
R2617 GND.n4709 GND.n4708 9.3
R2618 GND.n4689 GND.n4688 9.3
R2619 GND.n4427 GND.n4426 9.3
R2620 GND.n4408 GND.n4407 9.3
R2621 GND.n4406 GND.n4405 9.3
R2622 GND.n4416 GND.n4415 9.3
R2623 GND.n4415 GND.n4414 9.3
R2624 GND.n4425 GND.n4424 9.3
R2625 GND.n4424 GND.n4423 9.3
R2626 GND.n4429 GND.n4428 9.3
R2627 GND.n4398 GND.n4397 9.3
R2628 GND.n4397 GND.n4396 9.3
R2629 GND.n4754 GND.n4753 9.3
R2630 GND.n4735 GND.n4734 9.3
R2631 GND.n4733 GND.n4732 9.3
R2632 GND.n4756 GND.n4755 9.3
R2633 GND.n4743 GND.n4742 9.3
R2634 GND.n4742 GND.n4741 9.3
R2635 GND.n4752 GND.n4751 9.3
R2636 GND.n4751 GND.n4750 9.3
R2637 GND.n4731 GND.n4730 9.3
R2638 GND.n4387 GND.n4386 9.3
R2639 GND.n4368 GND.n4367 9.3
R2640 GND.n4366 GND.n4365 9.3
R2641 GND.n4376 GND.n4375 9.3
R2642 GND.n4375 GND.n4374 9.3
R2643 GND.n4385 GND.n4384 9.3
R2644 GND.n4384 GND.n4383 9.3
R2645 GND.n4389 GND.n4388 9.3
R2646 GND.n4358 GND.n4357 9.3
R2647 GND.n4357 GND.n4356 9.3
R2648 GND.n4796 GND.n4795 9.3
R2649 GND.n4777 GND.n4776 9.3
R2650 GND.n4775 GND.n4774 9.3
R2651 GND.n4798 GND.n4797 9.3
R2652 GND.n4785 GND.n4784 9.3
R2653 GND.n4784 GND.n4783 9.3
R2654 GND.n4794 GND.n4793 9.3
R2655 GND.n4793 GND.n4792 9.3
R2656 GND.n4773 GND.n4772 9.3
R2657 GND.n4347 GND.n4346 9.3
R2658 GND.n4328 GND.n4327 9.3
R2659 GND.n4326 GND.n4325 9.3
R2660 GND.n4336 GND.n4335 9.3
R2661 GND.n4335 GND.n4334 9.3
R2662 GND.n4345 GND.n4344 9.3
R2663 GND.n4344 GND.n4343 9.3
R2664 GND.n4349 GND.n4348 9.3
R2665 GND.n4318 GND.n4317 9.3
R2666 GND.n4317 GND.n4316 9.3
R2667 GND.n4838 GND.n4837 9.3
R2668 GND.n4819 GND.n4818 9.3
R2669 GND.n4817 GND.n4816 9.3
R2670 GND.n4840 GND.n4839 9.3
R2671 GND.n4827 GND.n4826 9.3
R2672 GND.n4826 GND.n4825 9.3
R2673 GND.n4836 GND.n4835 9.3
R2674 GND.n4835 GND.n4834 9.3
R2675 GND.n4815 GND.n4814 9.3
R2676 GND.n4307 GND.n4306 9.3
R2677 GND.n4288 GND.n4287 9.3
R2678 GND.n4286 GND.n4285 9.3
R2679 GND.n4296 GND.n4295 9.3
R2680 GND.n4295 GND.n4294 9.3
R2681 GND.n4305 GND.n4304 9.3
R2682 GND.n4304 GND.n4303 9.3
R2683 GND.n4309 GND.n4308 9.3
R2684 GND.n4278 GND.n4277 9.3
R2685 GND.n4277 GND.n4276 9.3
R2686 GND.n4880 GND.n4879 9.3
R2687 GND.n4861 GND.n4860 9.3
R2688 GND.n4859 GND.n4858 9.3
R2689 GND.n4882 GND.n4881 9.3
R2690 GND.n4869 GND.n4868 9.3
R2691 GND.n4868 GND.n4867 9.3
R2692 GND.n4878 GND.n4877 9.3
R2693 GND.n4877 GND.n4876 9.3
R2694 GND.n4857 GND.n4856 9.3
R2695 GND.n4267 GND.n4266 9.3
R2696 GND.n4248 GND.n4247 9.3
R2697 GND.n4246 GND.n4245 9.3
R2698 GND.n4256 GND.n4255 9.3
R2699 GND.n4255 GND.n4254 9.3
R2700 GND.n4265 GND.n4264 9.3
R2701 GND.n4264 GND.n4263 9.3
R2702 GND.n4269 GND.n4268 9.3
R2703 GND.n4238 GND.n4237 9.3
R2704 GND.n4237 GND.n4236 9.3
R2705 GND.n4923 GND.n4922 9.3
R2706 GND.n4904 GND.n4903 9.3
R2707 GND.n4902 GND.n4901 9.3
R2708 GND.n4925 GND.n4924 9.3
R2709 GND.n4912 GND.n4911 9.3
R2710 GND.n4911 GND.n4910 9.3
R2711 GND.n4921 GND.n4920 9.3
R2712 GND.n4920 GND.n4919 9.3
R2713 GND.n4900 GND.n4899 9.3
R2714 GND.n2916 GND.n2915 9.3
R2715 GND.n2897 GND.n2896 9.3
R2716 GND.n2895 GND.n2894 9.3
R2717 GND.n2905 GND.n2904 9.3
R2718 GND.n2904 GND.n2903 9.3
R2719 GND.n2914 GND.n2913 9.3
R2720 GND.n2913 GND.n2912 9.3
R2721 GND.n2918 GND.n2917 9.3
R2722 GND.n2887 GND.n2886 9.3
R2723 GND.n2886 GND.n2885 9.3
R2724 GND.n4965 GND.n4964 9.3
R2725 GND.n4946 GND.n4945 9.3
R2726 GND.n4944 GND.n4943 9.3
R2727 GND.n4967 GND.n4966 9.3
R2728 GND.n4954 GND.n4953 9.3
R2729 GND.n4953 GND.n4952 9.3
R2730 GND.n4963 GND.n4962 9.3
R2731 GND.n4962 GND.n4961 9.3
R2732 GND.n4942 GND.n4941 9.3
R2733 GND.n2876 GND.n2875 9.3
R2734 GND.n2857 GND.n2856 9.3
R2735 GND.n2855 GND.n2854 9.3
R2736 GND.n2865 GND.n2864 9.3
R2737 GND.n2864 GND.n2863 9.3
R2738 GND.n2874 GND.n2873 9.3
R2739 GND.n2873 GND.n2872 9.3
R2740 GND.n2878 GND.n2877 9.3
R2741 GND.n2847 GND.n2846 9.3
R2742 GND.n2846 GND.n2845 9.3
R2743 GND.n5007 GND.n5006 9.3
R2744 GND.n4988 GND.n4987 9.3
R2745 GND.n4986 GND.n4985 9.3
R2746 GND.n5009 GND.n5008 9.3
R2747 GND.n4996 GND.n4995 9.3
R2748 GND.n4995 GND.n4994 9.3
R2749 GND.n5005 GND.n5004 9.3
R2750 GND.n5004 GND.n5003 9.3
R2751 GND.n4984 GND.n4983 9.3
R2752 GND.n2836 GND.n2835 9.3
R2753 GND.n2817 GND.n2816 9.3
R2754 GND.n2815 GND.n2814 9.3
R2755 GND.n2825 GND.n2824 9.3
R2756 GND.n2824 GND.n2823 9.3
R2757 GND.n2834 GND.n2833 9.3
R2758 GND.n2833 GND.n2832 9.3
R2759 GND.n2838 GND.n2837 9.3
R2760 GND.n2807 GND.n2806 9.3
R2761 GND.n2806 GND.n2805 9.3
R2762 GND.n5049 GND.n5048 9.3
R2763 GND.n5030 GND.n5029 9.3
R2764 GND.n5028 GND.n5027 9.3
R2765 GND.n5051 GND.n5050 9.3
R2766 GND.n5038 GND.n5037 9.3
R2767 GND.n5037 GND.n5036 9.3
R2768 GND.n5047 GND.n5046 9.3
R2769 GND.n5046 GND.n5045 9.3
R2770 GND.n5026 GND.n5025 9.3
R2771 GND.n2796 GND.n2795 9.3
R2772 GND.n2777 GND.n2776 9.3
R2773 GND.n2775 GND.n2774 9.3
R2774 GND.n2785 GND.n2784 9.3
R2775 GND.n2784 GND.n2783 9.3
R2776 GND.n2794 GND.n2793 9.3
R2777 GND.n2793 GND.n2792 9.3
R2778 GND.n2798 GND.n2797 9.3
R2779 GND.n2767 GND.n2766 9.3
R2780 GND.n2766 GND.n2765 9.3
R2781 GND.n5091 GND.n5090 9.3
R2782 GND.n5072 GND.n5071 9.3
R2783 GND.n5070 GND.n5069 9.3
R2784 GND.n5093 GND.n5092 9.3
R2785 GND.n5080 GND.n5079 9.3
R2786 GND.n5079 GND.n5078 9.3
R2787 GND.n5089 GND.n5088 9.3
R2788 GND.n5088 GND.n5087 9.3
R2789 GND.n5068 GND.n5067 9.3
R2790 GND.n2756 GND.n2755 9.3
R2791 GND.n2737 GND.n2736 9.3
R2792 GND.n2735 GND.n2734 9.3
R2793 GND.n2745 GND.n2744 9.3
R2794 GND.n2744 GND.n2743 9.3
R2795 GND.n2754 GND.n2753 9.3
R2796 GND.n2753 GND.n2752 9.3
R2797 GND.n2758 GND.n2757 9.3
R2798 GND.n2727 GND.n2726 9.3
R2799 GND.n2726 GND.n2725 9.3
R2800 GND.n5133 GND.n5132 9.3
R2801 GND.n5114 GND.n5113 9.3
R2802 GND.n5112 GND.n5111 9.3
R2803 GND.n5135 GND.n5134 9.3
R2804 GND.n5122 GND.n5121 9.3
R2805 GND.n5121 GND.n5120 9.3
R2806 GND.n5131 GND.n5130 9.3
R2807 GND.n5130 GND.n5129 9.3
R2808 GND.n5110 GND.n5109 9.3
R2809 GND.n2716 GND.n2715 9.3
R2810 GND.n2697 GND.n2696 9.3
R2811 GND.n2695 GND.n2694 9.3
R2812 GND.n2705 GND.n2704 9.3
R2813 GND.n2704 GND.n2703 9.3
R2814 GND.n2714 GND.n2713 9.3
R2815 GND.n2713 GND.n2712 9.3
R2816 GND.n2718 GND.n2717 9.3
R2817 GND.n2687 GND.n2686 9.3
R2818 GND.n2686 GND.n2685 9.3
R2819 GND.n5175 GND.n5174 9.3
R2820 GND.n5156 GND.n5155 9.3
R2821 GND.n5154 GND.n5153 9.3
R2822 GND.n5177 GND.n5176 9.3
R2823 GND.n5164 GND.n5163 9.3
R2824 GND.n5163 GND.n5162 9.3
R2825 GND.n5173 GND.n5172 9.3
R2826 GND.n5172 GND.n5171 9.3
R2827 GND.n5152 GND.n5151 9.3
R2828 GND.n2676 GND.n2675 9.3
R2829 GND.n2657 GND.n2656 9.3
R2830 GND.n2655 GND.n2654 9.3
R2831 GND.n2665 GND.n2664 9.3
R2832 GND.n2664 GND.n2663 9.3
R2833 GND.n2674 GND.n2673 9.3
R2834 GND.n2673 GND.n2672 9.3
R2835 GND.n2678 GND.n2677 9.3
R2836 GND.n2647 GND.n2646 9.3
R2837 GND.n2646 GND.n2645 9.3
R2838 GND.n5217 GND.n5216 9.3
R2839 GND.n5198 GND.n5197 9.3
R2840 GND.n5196 GND.n5195 9.3
R2841 GND.n5219 GND.n5218 9.3
R2842 GND.n5206 GND.n5205 9.3
R2843 GND.n5205 GND.n5204 9.3
R2844 GND.n5215 GND.n5214 9.3
R2845 GND.n5214 GND.n5213 9.3
R2846 GND.n5194 GND.n5193 9.3
R2847 GND.n2636 GND.n2635 9.3
R2848 GND.n2617 GND.n2616 9.3
R2849 GND.n2615 GND.n2614 9.3
R2850 GND.n2625 GND.n2624 9.3
R2851 GND.n2624 GND.n2623 9.3
R2852 GND.n2634 GND.n2633 9.3
R2853 GND.n2633 GND.n2632 9.3
R2854 GND.n2638 GND.n2637 9.3
R2855 GND.n2607 GND.n2606 9.3
R2856 GND.n2606 GND.n2605 9.3
R2857 GND.n53 GND.n52 9.001
R2858 GND.n45 GND.n44 9.001
R2859 GND.n185 GND.n184 9.001
R2860 GND.n226 GND.n225 9.001
R2861 GND.n439 GND.n438 9.001
R2862 GND.n480 GND.n479 9.001
R2863 GND.n522 GND.n521 9.001
R2864 GND.n564 GND.n563 9.001
R2865 GND.n937 GND.n936 9.001
R2866 GND.n978 GND.n977 9.001
R2867 GND.n1020 GND.n1019 9.001
R2868 GND.n1062 GND.n1061 9.001
R2869 GND.n1104 GND.n1103 9.001
R2870 GND.n1146 GND.n1145 9.001
R2871 GND.n1188 GND.n1187 9.001
R2872 GND.n1230 GND.n1229 9.001
R2873 GND.n1923 GND.n1922 9.001
R2874 GND.n1964 GND.n1963 9.001
R2875 GND.n2006 GND.n2005 9.001
R2876 GND.n2048 GND.n2047 9.001
R2877 GND.n2090 GND.n2089 9.001
R2878 GND.n2132 GND.n2131 9.001
R2879 GND.n2174 GND.n2173 9.001
R2880 GND.n2216 GND.n2215 9.001
R2881 GND.n2258 GND.n2257 9.001
R2882 GND.n2300 GND.n2299 9.001
R2883 GND.n2342 GND.n2341 9.001
R2884 GND.n2384 GND.n2383 9.001
R2885 GND.n2426 GND.n2425 9.001
R2886 GND.n2468 GND.n2467 9.001
R2887 GND.n2510 GND.n2509 9.001
R2888 GND.n2552 GND.n2551 9.001
R2889 GND.n3245 GND.n3244 9.001
R2890 GND.n3286 GND.n3285 9.001
R2891 GND.n3328 GND.n3327 9.001
R2892 GND.n3370 GND.n3369 9.001
R2893 GND.n3412 GND.n3411 9.001
R2894 GND.n3454 GND.n3453 9.001
R2895 GND.n3496 GND.n3495 9.001
R2896 GND.n3538 GND.n3537 9.001
R2897 GND.n3900 GND.n3899 9.001
R2898 GND.n3941 GND.n3940 9.001
R2899 GND.n3983 GND.n3982 9.001
R2900 GND.n4025 GND.n4024 9.001
R2901 GND.n4067 GND.n4066 9.001
R2902 GND.n4109 GND.n4108 9.001
R2903 GND.n4151 GND.n4150 9.001
R2904 GND.n4193 GND.n4192 9.001
R2905 GND.n4556 GND.n4555 9.001
R2906 GND.n4597 GND.n4596 9.001
R2907 GND.n4639 GND.n4638 9.001
R2908 GND.n4681 GND.n4680 9.001
R2909 GND.n4723 GND.n4722 9.001
R2910 GND.n4765 GND.n4764 9.001
R2911 GND.n4807 GND.n4806 9.001
R2912 GND.n4849 GND.n4848 9.001
R2913 GND.n4892 GND.n4891 9.001
R2914 GND.n4934 GND.n4933 9.001
R2915 GND.n4976 GND.n4975 9.001
R2916 GND.n5018 GND.n5017 9.001
R2917 GND.n5060 GND.n5059 9.001
R2918 GND.n5102 GND.n5101 9.001
R2919 GND.n5144 GND.n5143 9.001
R2920 GND.n5186 GND.n5185 9.001
R2921 GND.n4230 GND.n3574 6.549
R2922 GND.n4927 GND.n4886 6.549
R2923 GND.n67 GND.n66 6.023
R2924 GND.n75 GND.n74 6.023
R2925 GND.n19 GND.n18 6.023
R2926 GND.n28 GND.n27 6.023
R2927 GND.n199 GND.n198 6.023
R2928 GND.n207 GND.n206 6.023
R2929 GND.n159 GND.n158 6.023
R2930 GND.n167 GND.n166 6.023
R2931 GND.n240 GND.n239 6.023
R2932 GND.n248 GND.n247 6.023
R2933 GND.n119 GND.n118 6.023
R2934 GND.n127 GND.n126 6.023
R2935 GND.n453 GND.n452 6.023
R2936 GND.n461 GND.n460 6.023
R2937 GND.n413 GND.n412 6.023
R2938 GND.n421 GND.n420 6.023
R2939 GND.n494 GND.n493 6.023
R2940 GND.n502 GND.n501 6.023
R2941 GND.n373 GND.n372 6.023
R2942 GND.n381 GND.n380 6.023
R2943 GND.n536 GND.n535 6.023
R2944 GND.n544 GND.n543 6.023
R2945 GND.n333 GND.n332 6.023
R2946 GND.n341 GND.n340 6.023
R2947 GND.n578 GND.n577 6.023
R2948 GND.n586 GND.n585 6.023
R2949 GND.n293 GND.n292 6.023
R2950 GND.n301 GND.n300 6.023
R2951 GND.n951 GND.n950 6.023
R2952 GND.n959 GND.n958 6.023
R2953 GND.n911 GND.n910 6.023
R2954 GND.n919 GND.n918 6.023
R2955 GND.n992 GND.n991 6.023
R2956 GND.n1000 GND.n999 6.023
R2957 GND.n871 GND.n870 6.023
R2958 GND.n879 GND.n878 6.023
R2959 GND.n1034 GND.n1033 6.023
R2960 GND.n1042 GND.n1041 6.023
R2961 GND.n831 GND.n830 6.023
R2962 GND.n839 GND.n838 6.023
R2963 GND.n1076 GND.n1075 6.023
R2964 GND.n1084 GND.n1083 6.023
R2965 GND.n791 GND.n790 6.023
R2966 GND.n799 GND.n798 6.023
R2967 GND.n1118 GND.n1117 6.023
R2968 GND.n1126 GND.n1125 6.023
R2969 GND.n751 GND.n750 6.023
R2970 GND.n759 GND.n758 6.023
R2971 GND.n1160 GND.n1159 6.023
R2972 GND.n1168 GND.n1167 6.023
R2973 GND.n711 GND.n710 6.023
R2974 GND.n719 GND.n718 6.023
R2975 GND.n1202 GND.n1201 6.023
R2976 GND.n1210 GND.n1209 6.023
R2977 GND.n671 GND.n670 6.023
R2978 GND.n679 GND.n678 6.023
R2979 GND.n1244 GND.n1243 6.023
R2980 GND.n1252 GND.n1251 6.023
R2981 GND.n631 GND.n630 6.023
R2982 GND.n639 GND.n638 6.023
R2983 GND.n1937 GND.n1936 6.023
R2984 GND.n1945 GND.n1944 6.023
R2985 GND.n1897 GND.n1896 6.023
R2986 GND.n1905 GND.n1904 6.023
R2987 GND.n1978 GND.n1977 6.023
R2988 GND.n1986 GND.n1985 6.023
R2989 GND.n1857 GND.n1856 6.023
R2990 GND.n1865 GND.n1864 6.023
R2991 GND.n2020 GND.n2019 6.023
R2992 GND.n2028 GND.n2027 6.023
R2993 GND.n1817 GND.n1816 6.023
R2994 GND.n1825 GND.n1824 6.023
R2995 GND.n2062 GND.n2061 6.023
R2996 GND.n2070 GND.n2069 6.023
R2997 GND.n1777 GND.n1776 6.023
R2998 GND.n1785 GND.n1784 6.023
R2999 GND.n2104 GND.n2103 6.023
R3000 GND.n2112 GND.n2111 6.023
R3001 GND.n1737 GND.n1736 6.023
R3002 GND.n1745 GND.n1744 6.023
R3003 GND.n2146 GND.n2145 6.023
R3004 GND.n2154 GND.n2153 6.023
R3005 GND.n1697 GND.n1696 6.023
R3006 GND.n1705 GND.n1704 6.023
R3007 GND.n2188 GND.n2187 6.023
R3008 GND.n2196 GND.n2195 6.023
R3009 GND.n1657 GND.n1656 6.023
R3010 GND.n1665 GND.n1664 6.023
R3011 GND.n2230 GND.n2229 6.023
R3012 GND.n2238 GND.n2237 6.023
R3013 GND.n1617 GND.n1616 6.023
R3014 GND.n1625 GND.n1624 6.023
R3015 GND.n2272 GND.n2271 6.023
R3016 GND.n2280 GND.n2279 6.023
R3017 GND.n1577 GND.n1576 6.023
R3018 GND.n1585 GND.n1584 6.023
R3019 GND.n2314 GND.n2313 6.023
R3020 GND.n2322 GND.n2321 6.023
R3021 GND.n1537 GND.n1536 6.023
R3022 GND.n1545 GND.n1544 6.023
R3023 GND.n2356 GND.n2355 6.023
R3024 GND.n2364 GND.n2363 6.023
R3025 GND.n1497 GND.n1496 6.023
R3026 GND.n1505 GND.n1504 6.023
R3027 GND.n2398 GND.n2397 6.023
R3028 GND.n2406 GND.n2405 6.023
R3029 GND.n1457 GND.n1456 6.023
R3030 GND.n1465 GND.n1464 6.023
R3031 GND.n2440 GND.n2439 6.023
R3032 GND.n2448 GND.n2447 6.023
R3033 GND.n1417 GND.n1416 6.023
R3034 GND.n1425 GND.n1424 6.023
R3035 GND.n2482 GND.n2481 6.023
R3036 GND.n2490 GND.n2489 6.023
R3037 GND.n1377 GND.n1376 6.023
R3038 GND.n1385 GND.n1384 6.023
R3039 GND.n2524 GND.n2523 6.023
R3040 GND.n2532 GND.n2531 6.023
R3041 GND.n1337 GND.n1336 6.023
R3042 GND.n1345 GND.n1344 6.023
R3043 GND.n2566 GND.n2565 6.023
R3044 GND.n2574 GND.n2573 6.023
R3045 GND.n1297 GND.n1296 6.023
R3046 GND.n1305 GND.n1304 6.023
R3047 GND.n3259 GND.n3258 6.023
R3048 GND.n3267 GND.n3266 6.023
R3049 GND.n3219 GND.n3218 6.023
R3050 GND.n3227 GND.n3226 6.023
R3051 GND.n3300 GND.n3299 6.023
R3052 GND.n3308 GND.n3307 6.023
R3053 GND.n3179 GND.n3178 6.023
R3054 GND.n3187 GND.n3186 6.023
R3055 GND.n3342 GND.n3341 6.023
R3056 GND.n3350 GND.n3349 6.023
R3057 GND.n3139 GND.n3138 6.023
R3058 GND.n3147 GND.n3146 6.023
R3059 GND.n3384 GND.n3383 6.023
R3060 GND.n3392 GND.n3391 6.023
R3061 GND.n3099 GND.n3098 6.023
R3062 GND.n3107 GND.n3106 6.023
R3063 GND.n3426 GND.n3425 6.023
R3064 GND.n3434 GND.n3433 6.023
R3065 GND.n3059 GND.n3058 6.023
R3066 GND.n3067 GND.n3066 6.023
R3067 GND.n3468 GND.n3467 6.023
R3068 GND.n3476 GND.n3475 6.023
R3069 GND.n3019 GND.n3018 6.023
R3070 GND.n3027 GND.n3026 6.023
R3071 GND.n3510 GND.n3509 6.023
R3072 GND.n3518 GND.n3517 6.023
R3073 GND.n2979 GND.n2978 6.023
R3074 GND.n2987 GND.n2986 6.023
R3075 GND.n3552 GND.n3551 6.023
R3076 GND.n3560 GND.n3559 6.023
R3077 GND.n2939 GND.n2938 6.023
R3078 GND.n2947 GND.n2946 6.023
R3079 GND.n3914 GND.n3913 6.023
R3080 GND.n3922 GND.n3921 6.023
R3081 GND.n3874 GND.n3873 6.023
R3082 GND.n3882 GND.n3881 6.023
R3083 GND.n3955 GND.n3954 6.023
R3084 GND.n3963 GND.n3962 6.023
R3085 GND.n3834 GND.n3833 6.023
R3086 GND.n3842 GND.n3841 6.023
R3087 GND.n3997 GND.n3996 6.023
R3088 GND.n4005 GND.n4004 6.023
R3089 GND.n3794 GND.n3793 6.023
R3090 GND.n3802 GND.n3801 6.023
R3091 GND.n4039 GND.n4038 6.023
R3092 GND.n4047 GND.n4046 6.023
R3093 GND.n3754 GND.n3753 6.023
R3094 GND.n3762 GND.n3761 6.023
R3095 GND.n4081 GND.n4080 6.023
R3096 GND.n4089 GND.n4088 6.023
R3097 GND.n3714 GND.n3713 6.023
R3098 GND.n3722 GND.n3721 6.023
R3099 GND.n4123 GND.n4122 6.023
R3100 GND.n4131 GND.n4130 6.023
R3101 GND.n3674 GND.n3673 6.023
R3102 GND.n3682 GND.n3681 6.023
R3103 GND.n4165 GND.n4164 6.023
R3104 GND.n4173 GND.n4172 6.023
R3105 GND.n3634 GND.n3633 6.023
R3106 GND.n3642 GND.n3641 6.023
R3107 GND.n4207 GND.n4206 6.023
R3108 GND.n4215 GND.n4214 6.023
R3109 GND.n3594 GND.n3593 6.023
R3110 GND.n3602 GND.n3601 6.023
R3111 GND.n4570 GND.n4569 6.023
R3112 GND.n4578 GND.n4577 6.023
R3113 GND.n4530 GND.n4529 6.023
R3114 GND.n4538 GND.n4537 6.023
R3115 GND.n4611 GND.n4610 6.023
R3116 GND.n4619 GND.n4618 6.023
R3117 GND.n4490 GND.n4489 6.023
R3118 GND.n4498 GND.n4497 6.023
R3119 GND.n4653 GND.n4652 6.023
R3120 GND.n4661 GND.n4660 6.023
R3121 GND.n4450 GND.n4449 6.023
R3122 GND.n4458 GND.n4457 6.023
R3123 GND.n4695 GND.n4694 6.023
R3124 GND.n4703 GND.n4702 6.023
R3125 GND.n4410 GND.n4409 6.023
R3126 GND.n4418 GND.n4417 6.023
R3127 GND.n4737 GND.n4736 6.023
R3128 GND.n4745 GND.n4744 6.023
R3129 GND.n4370 GND.n4369 6.023
R3130 GND.n4378 GND.n4377 6.023
R3131 GND.n4779 GND.n4778 6.023
R3132 GND.n4787 GND.n4786 6.023
R3133 GND.n4330 GND.n4329 6.023
R3134 GND.n4338 GND.n4337 6.023
R3135 GND.n4821 GND.n4820 6.023
R3136 GND.n4829 GND.n4828 6.023
R3137 GND.n4290 GND.n4289 6.023
R3138 GND.n4298 GND.n4297 6.023
R3139 GND.n4863 GND.n4862 6.023
R3140 GND.n4871 GND.n4870 6.023
R3141 GND.n4250 GND.n4249 6.023
R3142 GND.n4258 GND.n4257 6.023
R3143 GND.n4906 GND.n4905 6.023
R3144 GND.n4914 GND.n4913 6.023
R3145 GND.n2899 GND.n2898 6.023
R3146 GND.n2907 GND.n2906 6.023
R3147 GND.n4948 GND.n4947 6.023
R3148 GND.n4956 GND.n4955 6.023
R3149 GND.n2859 GND.n2858 6.023
R3150 GND.n2867 GND.n2866 6.023
R3151 GND.n4990 GND.n4989 6.023
R3152 GND.n4998 GND.n4997 6.023
R3153 GND.n2819 GND.n2818 6.023
R3154 GND.n2827 GND.n2826 6.023
R3155 GND.n5032 GND.n5031 6.023
R3156 GND.n5040 GND.n5039 6.023
R3157 GND.n2779 GND.n2778 6.023
R3158 GND.n2787 GND.n2786 6.023
R3159 GND.n5074 GND.n5073 6.023
R3160 GND.n5082 GND.n5081 6.023
R3161 GND.n2739 GND.n2738 6.023
R3162 GND.n2747 GND.n2746 6.023
R3163 GND.n5116 GND.n5115 6.023
R3164 GND.n5124 GND.n5123 6.023
R3165 GND.n2699 GND.n2698 6.023
R3166 GND.n2707 GND.n2706 6.023
R3167 GND.n5158 GND.n5157 6.023
R3168 GND.n5166 GND.n5165 6.023
R3169 GND.n2659 GND.n2658 6.023
R3170 GND.n2667 GND.n2666 6.023
R3171 GND.n5200 GND.n5199 6.023
R3172 GND.n5208 GND.n5207 6.023
R3173 GND.n2619 GND.n2618 6.023
R3174 GND.n2627 GND.n2626 6.023
R3175 GND.n261 GND.n220 5.992
R3176 GND.n515 GND.n474 5.992
R3177 GND.n557 GND.n516 5.992
R3178 GND.n599 GND.n558 5.992
R3179 GND.n1013 GND.n972 5.992
R3180 GND.n1055 GND.n1014 5.992
R3181 GND.n1097 GND.n1056 5.992
R3182 GND.n1139 GND.n1098 5.992
R3183 GND.n1181 GND.n1140 5.992
R3184 GND.n1223 GND.n1182 5.992
R3185 GND.n1265 GND.n1224 5.992
R3186 GND.n1999 GND.n1958 5.992
R3187 GND.n2041 GND.n2000 5.992
R3188 GND.n2083 GND.n2042 5.992
R3189 GND.n2125 GND.n2084 5.992
R3190 GND.n2167 GND.n2126 5.992
R3191 GND.n2209 GND.n2168 5.992
R3192 GND.n2251 GND.n2210 5.992
R3193 GND.n2335 GND.n2294 5.992
R3194 GND.n2377 GND.n2336 5.992
R3195 GND.n2419 GND.n2378 5.992
R3196 GND.n2461 GND.n2420 5.992
R3197 GND.n2503 GND.n2462 5.992
R3198 GND.n2545 GND.n2504 5.992
R3199 GND.n2587 GND.n2546 5.992
R3200 GND.n3321 GND.n3280 5.992
R3201 GND.n3363 GND.n3322 5.992
R3202 GND.n3405 GND.n3364 5.992
R3203 GND.n3447 GND.n3406 5.992
R3204 GND.n3489 GND.n3448 5.992
R3205 GND.n3531 GND.n3490 5.992
R3206 GND.n3573 GND.n3532 5.992
R3207 GND.n3976 GND.n3935 5.992
R3208 GND.n4018 GND.n3977 5.992
R3209 GND.n4060 GND.n4019 5.992
R3210 GND.n4102 GND.n4061 5.992
R3211 GND.n4144 GND.n4103 5.992
R3212 GND.n4186 GND.n4145 5.992
R3213 GND.n4228 GND.n4187 5.992
R3214 GND.n4632 GND.n4591 5.992
R3215 GND.n4674 GND.n4633 5.992
R3216 GND.n4716 GND.n4675 5.992
R3217 GND.n4758 GND.n4717 5.992
R3218 GND.n4800 GND.n4759 5.992
R3219 GND.n4842 GND.n4801 5.992
R3220 GND.n4884 GND.n4843 5.992
R3221 GND.n4969 GND.n4928 5.992
R3222 GND.n5011 GND.n4970 5.992
R3223 GND.n5053 GND.n5012 5.992
R3224 GND.n5095 GND.n5054 5.992
R3225 GND.n5137 GND.n5096 5.992
R3226 GND.n5179 GND.n5138 5.992
R3227 GND.n5221 GND.n5180 5.992
R3228 GND.n56 GND.n55 5.27
R3229 GND.n49 GND.n48 5.27
R3230 GND.n9 GND.n8 5.27
R3231 GND.n41 GND.n40 5.27
R3232 GND.n188 GND.n187 5.27
R3233 GND.n181 GND.n180 5.27
R3234 GND.n149 GND.n148 5.27
R3235 GND.n141 GND.n140 5.27
R3236 GND.n229 GND.n228 5.27
R3237 GND.n222 GND.n221 5.27
R3238 GND.n109 GND.n108 5.27
R3239 GND.n101 GND.n100 5.27
R3240 GND.n442 GND.n441 5.27
R3241 GND.n435 GND.n434 5.27
R3242 GND.n403 GND.n402 5.27
R3243 GND.n395 GND.n394 5.27
R3244 GND.n483 GND.n482 5.27
R3245 GND.n476 GND.n475 5.27
R3246 GND.n363 GND.n362 5.27
R3247 GND.n355 GND.n354 5.27
R3248 GND.n525 GND.n524 5.27
R3249 GND.n518 GND.n517 5.27
R3250 GND.n323 GND.n322 5.27
R3251 GND.n315 GND.n314 5.27
R3252 GND.n567 GND.n566 5.27
R3253 GND.n560 GND.n559 5.27
R3254 GND.n283 GND.n282 5.27
R3255 GND.n275 GND.n274 5.27
R3256 GND.n940 GND.n939 5.27
R3257 GND.n933 GND.n932 5.27
R3258 GND.n901 GND.n900 5.27
R3259 GND.n893 GND.n892 5.27
R3260 GND.n981 GND.n980 5.27
R3261 GND.n974 GND.n973 5.27
R3262 GND.n861 GND.n860 5.27
R3263 GND.n853 GND.n852 5.27
R3264 GND.n1023 GND.n1022 5.27
R3265 GND.n1016 GND.n1015 5.27
R3266 GND.n821 GND.n820 5.27
R3267 GND.n813 GND.n812 5.27
R3268 GND.n1065 GND.n1064 5.27
R3269 GND.n1058 GND.n1057 5.27
R3270 GND.n781 GND.n780 5.27
R3271 GND.n773 GND.n772 5.27
R3272 GND.n1107 GND.n1106 5.27
R3273 GND.n1100 GND.n1099 5.27
R3274 GND.n741 GND.n740 5.27
R3275 GND.n733 GND.n732 5.27
R3276 GND.n1149 GND.n1148 5.27
R3277 GND.n1142 GND.n1141 5.27
R3278 GND.n701 GND.n700 5.27
R3279 GND.n693 GND.n692 5.27
R3280 GND.n1191 GND.n1190 5.27
R3281 GND.n1184 GND.n1183 5.27
R3282 GND.n661 GND.n660 5.27
R3283 GND.n653 GND.n652 5.27
R3284 GND.n1233 GND.n1232 5.27
R3285 GND.n1226 GND.n1225 5.27
R3286 GND.n621 GND.n620 5.27
R3287 GND.n613 GND.n612 5.27
R3288 GND.n1926 GND.n1925 5.27
R3289 GND.n1919 GND.n1918 5.27
R3290 GND.n1887 GND.n1886 5.27
R3291 GND.n1879 GND.n1878 5.27
R3292 GND.n1967 GND.n1966 5.27
R3293 GND.n1960 GND.n1959 5.27
R3294 GND.n1847 GND.n1846 5.27
R3295 GND.n1839 GND.n1838 5.27
R3296 GND.n2009 GND.n2008 5.27
R3297 GND.n2002 GND.n2001 5.27
R3298 GND.n1807 GND.n1806 5.27
R3299 GND.n1799 GND.n1798 5.27
R3300 GND.n2051 GND.n2050 5.27
R3301 GND.n2044 GND.n2043 5.27
R3302 GND.n1767 GND.n1766 5.27
R3303 GND.n1759 GND.n1758 5.27
R3304 GND.n2093 GND.n2092 5.27
R3305 GND.n2086 GND.n2085 5.27
R3306 GND.n1727 GND.n1726 5.27
R3307 GND.n1719 GND.n1718 5.27
R3308 GND.n2135 GND.n2134 5.27
R3309 GND.n2128 GND.n2127 5.27
R3310 GND.n1687 GND.n1686 5.27
R3311 GND.n1679 GND.n1678 5.27
R3312 GND.n2177 GND.n2176 5.27
R3313 GND.n2170 GND.n2169 5.27
R3314 GND.n1647 GND.n1646 5.27
R3315 GND.n1639 GND.n1638 5.27
R3316 GND.n2219 GND.n2218 5.27
R3317 GND.n2212 GND.n2211 5.27
R3318 GND.n1607 GND.n1606 5.27
R3319 GND.n1599 GND.n1598 5.27
R3320 GND.n2261 GND.n2260 5.27
R3321 GND.n2254 GND.n2253 5.27
R3322 GND.n1567 GND.n1566 5.27
R3323 GND.n1559 GND.n1558 5.27
R3324 GND.n2303 GND.n2302 5.27
R3325 GND.n2296 GND.n2295 5.27
R3326 GND.n1527 GND.n1526 5.27
R3327 GND.n1519 GND.n1518 5.27
R3328 GND.n2345 GND.n2344 5.27
R3329 GND.n2338 GND.n2337 5.27
R3330 GND.n1487 GND.n1486 5.27
R3331 GND.n1479 GND.n1478 5.27
R3332 GND.n2387 GND.n2386 5.27
R3333 GND.n2380 GND.n2379 5.27
R3334 GND.n1447 GND.n1446 5.27
R3335 GND.n1439 GND.n1438 5.27
R3336 GND.n2429 GND.n2428 5.27
R3337 GND.n2422 GND.n2421 5.27
R3338 GND.n1407 GND.n1406 5.27
R3339 GND.n1399 GND.n1398 5.27
R3340 GND.n2471 GND.n2470 5.27
R3341 GND.n2464 GND.n2463 5.27
R3342 GND.n1367 GND.n1366 5.27
R3343 GND.n1359 GND.n1358 5.27
R3344 GND.n2513 GND.n2512 5.27
R3345 GND.n2506 GND.n2505 5.27
R3346 GND.n1327 GND.n1326 5.27
R3347 GND.n1319 GND.n1318 5.27
R3348 GND.n2555 GND.n2554 5.27
R3349 GND.n2548 GND.n2547 5.27
R3350 GND.n1287 GND.n1286 5.27
R3351 GND.n1279 GND.n1278 5.27
R3352 GND.n3248 GND.n3247 5.27
R3353 GND.n3241 GND.n3240 5.27
R3354 GND.n3209 GND.n3208 5.27
R3355 GND.n3201 GND.n3200 5.27
R3356 GND.n3289 GND.n3288 5.27
R3357 GND.n3282 GND.n3281 5.27
R3358 GND.n3169 GND.n3168 5.27
R3359 GND.n3161 GND.n3160 5.27
R3360 GND.n3331 GND.n3330 5.27
R3361 GND.n3324 GND.n3323 5.27
R3362 GND.n3129 GND.n3128 5.27
R3363 GND.n3121 GND.n3120 5.27
R3364 GND.n3373 GND.n3372 5.27
R3365 GND.n3366 GND.n3365 5.27
R3366 GND.n3089 GND.n3088 5.27
R3367 GND.n3081 GND.n3080 5.27
R3368 GND.n3415 GND.n3414 5.27
R3369 GND.n3408 GND.n3407 5.27
R3370 GND.n3049 GND.n3048 5.27
R3371 GND.n3041 GND.n3040 5.27
R3372 GND.n3457 GND.n3456 5.27
R3373 GND.n3450 GND.n3449 5.27
R3374 GND.n3009 GND.n3008 5.27
R3375 GND.n3001 GND.n3000 5.27
R3376 GND.n3499 GND.n3498 5.27
R3377 GND.n3492 GND.n3491 5.27
R3378 GND.n2969 GND.n2968 5.27
R3379 GND.n2961 GND.n2960 5.27
R3380 GND.n3541 GND.n3540 5.27
R3381 GND.n3534 GND.n3533 5.27
R3382 GND.n2929 GND.n2928 5.27
R3383 GND.n2921 GND.n2920 5.27
R3384 GND.n3903 GND.n3902 5.27
R3385 GND.n3896 GND.n3895 5.27
R3386 GND.n3864 GND.n3863 5.27
R3387 GND.n3856 GND.n3855 5.27
R3388 GND.n3944 GND.n3943 5.27
R3389 GND.n3937 GND.n3936 5.27
R3390 GND.n3824 GND.n3823 5.27
R3391 GND.n3816 GND.n3815 5.27
R3392 GND.n3986 GND.n3985 5.27
R3393 GND.n3979 GND.n3978 5.27
R3394 GND.n3784 GND.n3783 5.27
R3395 GND.n3776 GND.n3775 5.27
R3396 GND.n4028 GND.n4027 5.27
R3397 GND.n4021 GND.n4020 5.27
R3398 GND.n3744 GND.n3743 5.27
R3399 GND.n3736 GND.n3735 5.27
R3400 GND.n4070 GND.n4069 5.27
R3401 GND.n4063 GND.n4062 5.27
R3402 GND.n3704 GND.n3703 5.27
R3403 GND.n3696 GND.n3695 5.27
R3404 GND.n4112 GND.n4111 5.27
R3405 GND.n4105 GND.n4104 5.27
R3406 GND.n3664 GND.n3663 5.27
R3407 GND.n3656 GND.n3655 5.27
R3408 GND.n4154 GND.n4153 5.27
R3409 GND.n4147 GND.n4146 5.27
R3410 GND.n3624 GND.n3623 5.27
R3411 GND.n3616 GND.n3615 5.27
R3412 GND.n4196 GND.n4195 5.27
R3413 GND.n4189 GND.n4188 5.27
R3414 GND.n3584 GND.n3583 5.27
R3415 GND.n3576 GND.n3575 5.27
R3416 GND.n4559 GND.n4558 5.27
R3417 GND.n4552 GND.n4551 5.27
R3418 GND.n4520 GND.n4519 5.27
R3419 GND.n4512 GND.n4511 5.27
R3420 GND.n4600 GND.n4599 5.27
R3421 GND.n4593 GND.n4592 5.27
R3422 GND.n4480 GND.n4479 5.27
R3423 GND.n4472 GND.n4471 5.27
R3424 GND.n4642 GND.n4641 5.27
R3425 GND.n4635 GND.n4634 5.27
R3426 GND.n4440 GND.n4439 5.27
R3427 GND.n4432 GND.n4431 5.27
R3428 GND.n4684 GND.n4683 5.27
R3429 GND.n4677 GND.n4676 5.27
R3430 GND.n4400 GND.n4399 5.27
R3431 GND.n4392 GND.n4391 5.27
R3432 GND.n4726 GND.n4725 5.27
R3433 GND.n4719 GND.n4718 5.27
R3434 GND.n4360 GND.n4359 5.27
R3435 GND.n4352 GND.n4351 5.27
R3436 GND.n4768 GND.n4767 5.27
R3437 GND.n4761 GND.n4760 5.27
R3438 GND.n4320 GND.n4319 5.27
R3439 GND.n4312 GND.n4311 5.27
R3440 GND.n4810 GND.n4809 5.27
R3441 GND.n4803 GND.n4802 5.27
R3442 GND.n4280 GND.n4279 5.27
R3443 GND.n4272 GND.n4271 5.27
R3444 GND.n4852 GND.n4851 5.27
R3445 GND.n4845 GND.n4844 5.27
R3446 GND.n4240 GND.n4239 5.27
R3447 GND.n4232 GND.n4231 5.27
R3448 GND.n4895 GND.n4894 5.27
R3449 GND.n4888 GND.n4887 5.27
R3450 GND.n2889 GND.n2888 5.27
R3451 GND.n2881 GND.n2880 5.27
R3452 GND.n4937 GND.n4936 5.27
R3453 GND.n4930 GND.n4929 5.27
R3454 GND.n2849 GND.n2848 5.27
R3455 GND.n2841 GND.n2840 5.27
R3456 GND.n4979 GND.n4978 5.27
R3457 GND.n4972 GND.n4971 5.27
R3458 GND.n2809 GND.n2808 5.27
R3459 GND.n2801 GND.n2800 5.27
R3460 GND.n5021 GND.n5020 5.27
R3461 GND.n5014 GND.n5013 5.27
R3462 GND.n2769 GND.n2768 5.27
R3463 GND.n2761 GND.n2760 5.27
R3464 GND.n5063 GND.n5062 5.27
R3465 GND.n5056 GND.n5055 5.27
R3466 GND.n2729 GND.n2728 5.27
R3467 GND.n2721 GND.n2720 5.27
R3468 GND.n5105 GND.n5104 5.27
R3469 GND.n5098 GND.n5097 5.27
R3470 GND.n2689 GND.n2688 5.27
R3471 GND.n2681 GND.n2680 5.27
R3472 GND.n5147 GND.n5146 5.27
R3473 GND.n5140 GND.n5139 5.27
R3474 GND.n2649 GND.n2648 5.27
R3475 GND.n2641 GND.n2640 5.27
R3476 GND.n5189 GND.n5188 5.27
R3477 GND.n5182 GND.n5181 5.27
R3478 GND.n2609 GND.n2608 5.27
R3479 GND.n2601 GND.n2600 5.27
R3480 GND.n5227 GND.n5226 4.575
R3481 GND.n89 GND.n88 4.418
R3482 GND.n263 GND.n262 4.418
R3483 GND.n601 GND.n600 4.418
R3484 GND.n1267 GND.n1266 4.418
R3485 GND.n2589 GND.n2588 4.418
R3486 GND.n5223 GND.n5222 4.418
R3487 GND.n15 GND.n13 4.048
R3488 GND.n155 GND.n153 4.048
R3489 GND.n115 GND.n113 4.048
R3490 GND.n409 GND.n407 4.048
R3491 GND.n369 GND.n367 4.048
R3492 GND.n329 GND.n327 4.048
R3493 GND.n289 GND.n287 4.048
R3494 GND.n907 GND.n905 4.048
R3495 GND.n867 GND.n865 4.048
R3496 GND.n827 GND.n825 4.048
R3497 GND.n787 GND.n785 4.048
R3498 GND.n747 GND.n745 4.048
R3499 GND.n707 GND.n705 4.048
R3500 GND.n667 GND.n665 4.048
R3501 GND.n627 GND.n625 4.048
R3502 GND.n1893 GND.n1891 4.048
R3503 GND.n1853 GND.n1851 4.048
R3504 GND.n1813 GND.n1811 4.048
R3505 GND.n1773 GND.n1771 4.048
R3506 GND.n1733 GND.n1731 4.048
R3507 GND.n1693 GND.n1691 4.048
R3508 GND.n1653 GND.n1651 4.048
R3509 GND.n1613 GND.n1611 4.048
R3510 GND.n1573 GND.n1571 4.048
R3511 GND.n1533 GND.n1531 4.048
R3512 GND.n1493 GND.n1491 4.048
R3513 GND.n1453 GND.n1451 4.048
R3514 GND.n1413 GND.n1411 4.048
R3515 GND.n1373 GND.n1371 4.048
R3516 GND.n1333 GND.n1331 4.048
R3517 GND.n1293 GND.n1291 4.048
R3518 GND.n3215 GND.n3213 4.048
R3519 GND.n3175 GND.n3173 4.048
R3520 GND.n3135 GND.n3133 4.048
R3521 GND.n3095 GND.n3093 4.048
R3522 GND.n3055 GND.n3053 4.048
R3523 GND.n3015 GND.n3013 4.048
R3524 GND.n2975 GND.n2973 4.048
R3525 GND.n2935 GND.n2933 4.048
R3526 GND.n3870 GND.n3868 4.048
R3527 GND.n3830 GND.n3828 4.048
R3528 GND.n3790 GND.n3788 4.048
R3529 GND.n3750 GND.n3748 4.048
R3530 GND.n3710 GND.n3708 4.048
R3531 GND.n3670 GND.n3668 4.048
R3532 GND.n3630 GND.n3628 4.048
R3533 GND.n3590 GND.n3588 4.048
R3534 GND.n4526 GND.n4524 4.048
R3535 GND.n4486 GND.n4484 4.048
R3536 GND.n4446 GND.n4444 4.048
R3537 GND.n4406 GND.n4404 4.048
R3538 GND.n4366 GND.n4364 4.048
R3539 GND.n4326 GND.n4324 4.048
R3540 GND.n4286 GND.n4284 4.048
R3541 GND.n4246 GND.n4244 4.048
R3542 GND.n2895 GND.n2893 4.048
R3543 GND.n2855 GND.n2853 4.048
R3544 GND.n2815 GND.n2813 4.048
R3545 GND.n2775 GND.n2773 4.048
R3546 GND.n2735 GND.n2733 4.048
R3547 GND.n2695 GND.n2693 4.048
R3548 GND.n2655 GND.n2653 4.048
R3549 GND.n2615 GND.n2613 4.048
R3550 GND.n63 GND.n61 4.047
R3551 GND.n195 GND.n193 4.047
R3552 GND.n236 GND.n234 4.047
R3553 GND.n449 GND.n447 4.047
R3554 GND.n490 GND.n488 4.047
R3555 GND.n532 GND.n530 4.047
R3556 GND.n574 GND.n572 4.047
R3557 GND.n947 GND.n945 4.047
R3558 GND.n988 GND.n986 4.047
R3559 GND.n1030 GND.n1028 4.047
R3560 GND.n1072 GND.n1070 4.047
R3561 GND.n1114 GND.n1112 4.047
R3562 GND.n1156 GND.n1154 4.047
R3563 GND.n1198 GND.n1196 4.047
R3564 GND.n1240 GND.n1238 4.047
R3565 GND.n1933 GND.n1931 4.047
R3566 GND.n1974 GND.n1972 4.047
R3567 GND.n2016 GND.n2014 4.047
R3568 GND.n2058 GND.n2056 4.047
R3569 GND.n2100 GND.n2098 4.047
R3570 GND.n2142 GND.n2140 4.047
R3571 GND.n2184 GND.n2182 4.047
R3572 GND.n2226 GND.n2224 4.047
R3573 GND.n2268 GND.n2266 4.047
R3574 GND.n2310 GND.n2308 4.047
R3575 GND.n2352 GND.n2350 4.047
R3576 GND.n2394 GND.n2392 4.047
R3577 GND.n2436 GND.n2434 4.047
R3578 GND.n2478 GND.n2476 4.047
R3579 GND.n2520 GND.n2518 4.047
R3580 GND.n2562 GND.n2560 4.047
R3581 GND.n3255 GND.n3253 4.047
R3582 GND.n3296 GND.n3294 4.047
R3583 GND.n3338 GND.n3336 4.047
R3584 GND.n3380 GND.n3378 4.047
R3585 GND.n3422 GND.n3420 4.047
R3586 GND.n3464 GND.n3462 4.047
R3587 GND.n3506 GND.n3504 4.047
R3588 GND.n3548 GND.n3546 4.047
R3589 GND.n3910 GND.n3908 4.047
R3590 GND.n3951 GND.n3949 4.047
R3591 GND.n3993 GND.n3991 4.047
R3592 GND.n4035 GND.n4033 4.047
R3593 GND.n4077 GND.n4075 4.047
R3594 GND.n4119 GND.n4117 4.047
R3595 GND.n4161 GND.n4159 4.047
R3596 GND.n4203 GND.n4201 4.047
R3597 GND.n4566 GND.n4564 4.047
R3598 GND.n4607 GND.n4605 4.047
R3599 GND.n4649 GND.n4647 4.047
R3600 GND.n4691 GND.n4689 4.047
R3601 GND.n4733 GND.n4731 4.047
R3602 GND.n4775 GND.n4773 4.047
R3603 GND.n4817 GND.n4815 4.047
R3604 GND.n4859 GND.n4857 4.047
R3605 GND.n4902 GND.n4900 4.047
R3606 GND.n4944 GND.n4942 4.047
R3607 GND.n4986 GND.n4984 4.047
R3608 GND.n5028 GND.n5026 4.047
R3609 GND.n5070 GND.n5068 4.047
R3610 GND.n5112 GND.n5110 4.047
R3611 GND.n5154 GND.n5152 4.047
R3612 GND.n5196 GND.n5194 4.047
R3613 GND.n87 GND.n54 3.924
R3614 GND.n47 GND.n46 3.924
R3615 GND.n219 GND.n186 3.924
R3616 GND.n179 GND.n147 3.924
R3617 GND.n260 GND.n227 3.924
R3618 GND.n139 GND.n107 3.924
R3619 GND.n473 GND.n440 3.924
R3620 GND.n433 GND.n401 3.924
R3621 GND.n514 GND.n481 3.924
R3622 GND.n393 GND.n361 3.924
R3623 GND.n556 GND.n523 3.924
R3624 GND.n353 GND.n321 3.924
R3625 GND.n598 GND.n565 3.924
R3626 GND.n313 GND.n281 3.924
R3627 GND.n971 GND.n938 3.924
R3628 GND.n931 GND.n899 3.924
R3629 GND.n1012 GND.n979 3.924
R3630 GND.n891 GND.n859 3.924
R3631 GND.n1054 GND.n1021 3.924
R3632 GND.n851 GND.n819 3.924
R3633 GND.n1096 GND.n1063 3.924
R3634 GND.n811 GND.n779 3.924
R3635 GND.n1138 GND.n1105 3.924
R3636 GND.n771 GND.n739 3.924
R3637 GND.n1180 GND.n1147 3.924
R3638 GND.n731 GND.n699 3.924
R3639 GND.n1222 GND.n1189 3.924
R3640 GND.n691 GND.n659 3.924
R3641 GND.n1264 GND.n1231 3.924
R3642 GND.n651 GND.n619 3.924
R3643 GND.n1957 GND.n1924 3.924
R3644 GND.n1917 GND.n1885 3.924
R3645 GND.n1998 GND.n1965 3.924
R3646 GND.n1877 GND.n1845 3.924
R3647 GND.n2040 GND.n2007 3.924
R3648 GND.n1837 GND.n1805 3.924
R3649 GND.n2082 GND.n2049 3.924
R3650 GND.n1797 GND.n1765 3.924
R3651 GND.n2124 GND.n2091 3.924
R3652 GND.n1757 GND.n1725 3.924
R3653 GND.n2166 GND.n2133 3.924
R3654 GND.n1717 GND.n1685 3.924
R3655 GND.n2208 GND.n2175 3.924
R3656 GND.n1677 GND.n1645 3.924
R3657 GND.n2250 GND.n2217 3.924
R3658 GND.n1637 GND.n1605 3.924
R3659 GND.n2292 GND.n2259 3.924
R3660 GND.n1597 GND.n1565 3.924
R3661 GND.n2334 GND.n2301 3.924
R3662 GND.n1557 GND.n1525 3.924
R3663 GND.n2376 GND.n2343 3.924
R3664 GND.n1517 GND.n1485 3.924
R3665 GND.n2418 GND.n2385 3.924
R3666 GND.n1477 GND.n1445 3.924
R3667 GND.n2460 GND.n2427 3.924
R3668 GND.n1437 GND.n1405 3.924
R3669 GND.n2502 GND.n2469 3.924
R3670 GND.n1397 GND.n1365 3.924
R3671 GND.n2544 GND.n2511 3.924
R3672 GND.n1357 GND.n1325 3.924
R3673 GND.n2586 GND.n2553 3.924
R3674 GND.n1317 GND.n1285 3.924
R3675 GND.n3279 GND.n3246 3.924
R3676 GND.n3239 GND.n3207 3.924
R3677 GND.n3320 GND.n3287 3.924
R3678 GND.n3199 GND.n3167 3.924
R3679 GND.n3362 GND.n3329 3.924
R3680 GND.n3159 GND.n3127 3.924
R3681 GND.n3404 GND.n3371 3.924
R3682 GND.n3119 GND.n3087 3.924
R3683 GND.n3446 GND.n3413 3.924
R3684 GND.n3079 GND.n3047 3.924
R3685 GND.n3488 GND.n3455 3.924
R3686 GND.n3039 GND.n3007 3.924
R3687 GND.n3530 GND.n3497 3.924
R3688 GND.n2999 GND.n2967 3.924
R3689 GND.n3572 GND.n3539 3.924
R3690 GND.n2959 GND.n2927 3.924
R3691 GND.n3934 GND.n3901 3.924
R3692 GND.n3894 GND.n3862 3.924
R3693 GND.n3975 GND.n3942 3.924
R3694 GND.n3854 GND.n3822 3.924
R3695 GND.n4017 GND.n3984 3.924
R3696 GND.n3814 GND.n3782 3.924
R3697 GND.n4059 GND.n4026 3.924
R3698 GND.n3774 GND.n3742 3.924
R3699 GND.n4101 GND.n4068 3.924
R3700 GND.n3734 GND.n3702 3.924
R3701 GND.n4143 GND.n4110 3.924
R3702 GND.n3694 GND.n3662 3.924
R3703 GND.n4185 GND.n4152 3.924
R3704 GND.n3654 GND.n3622 3.924
R3705 GND.n4227 GND.n4194 3.924
R3706 GND.n3614 GND.n3582 3.924
R3707 GND.n4590 GND.n4557 3.924
R3708 GND.n4550 GND.n4518 3.924
R3709 GND.n4631 GND.n4598 3.924
R3710 GND.n4510 GND.n4478 3.924
R3711 GND.n4673 GND.n4640 3.924
R3712 GND.n4470 GND.n4438 3.924
R3713 GND.n4715 GND.n4682 3.924
R3714 GND.n4430 GND.n4398 3.924
R3715 GND.n4757 GND.n4724 3.924
R3716 GND.n4390 GND.n4358 3.924
R3717 GND.n4799 GND.n4766 3.924
R3718 GND.n4350 GND.n4318 3.924
R3719 GND.n4841 GND.n4808 3.924
R3720 GND.n4310 GND.n4278 3.924
R3721 GND.n4883 GND.n4850 3.924
R3722 GND.n4270 GND.n4238 3.924
R3723 GND.n4926 GND.n4893 3.924
R3724 GND.n2919 GND.n2887 3.924
R3725 GND.n4968 GND.n4935 3.924
R3726 GND.n2879 GND.n2847 3.924
R3727 GND.n5010 GND.n4977 3.924
R3728 GND.n2839 GND.n2807 3.924
R3729 GND.n5052 GND.n5019 3.924
R3730 GND.n2799 GND.n2767 3.924
R3731 GND.n5094 GND.n5061 3.924
R3732 GND.n2759 GND.n2727 3.924
R3733 GND.n5136 GND.n5103 3.924
R3734 GND.n2719 GND.n2687 3.924
R3735 GND.n5178 GND.n5145 3.924
R3736 GND.n2679 GND.n2647 3.924
R3737 GND.n5220 GND.n5187 3.924
R3738 GND.n2639 GND.n2607 3.924
R3739 GND.n4230 GND.n4229 3.407
R3740 GND.n4886 GND.n4885 3.407
R3741 GND.n80 GND.n78 3.396
R3742 GND.n24 GND.n22 3.396
R3743 GND.n33 GND.n31 3.396
R3744 GND.n253 GND.n251 3.396
R3745 GND.n212 GND.n210 3.396
R3746 GND.n591 GND.n589 3.396
R3747 GND.n549 GND.n547 3.396
R3748 GND.n507 GND.n505 3.396
R3749 GND.n466 GND.n464 3.396
R3750 GND.n1257 GND.n1255 3.396
R3751 GND.n1215 GND.n1213 3.396
R3752 GND.n1173 GND.n1171 3.396
R3753 GND.n1131 GND.n1129 3.396
R3754 GND.n1089 GND.n1087 3.396
R3755 GND.n1047 GND.n1045 3.396
R3756 GND.n1005 GND.n1003 3.396
R3757 GND.n964 GND.n962 3.396
R3758 GND.n2579 GND.n2577 3.396
R3759 GND.n2537 GND.n2535 3.396
R3760 GND.n2495 GND.n2493 3.396
R3761 GND.n2453 GND.n2451 3.396
R3762 GND.n2411 GND.n2409 3.396
R3763 GND.n2369 GND.n2367 3.396
R3764 GND.n2327 GND.n2325 3.396
R3765 GND.n2285 GND.n2283 3.396
R3766 GND.n2243 GND.n2241 3.396
R3767 GND.n2201 GND.n2199 3.396
R3768 GND.n2159 GND.n2157 3.396
R3769 GND.n2117 GND.n2115 3.396
R3770 GND.n2075 GND.n2073 3.396
R3771 GND.n2033 GND.n2031 3.396
R3772 GND.n1991 GND.n1989 3.396
R3773 GND.n1950 GND.n1948 3.396
R3774 GND.n5213 GND.n5211 3.396
R3775 GND.n5171 GND.n5169 3.396
R3776 GND.n5129 GND.n5127 3.396
R3777 GND.n5087 GND.n5085 3.396
R3778 GND.n5045 GND.n5043 3.396
R3779 GND.n5003 GND.n5001 3.396
R3780 GND.n4961 GND.n4959 3.396
R3781 GND.n4919 GND.n4917 3.396
R3782 GND.n3565 GND.n3563 3.396
R3783 GND.n3523 GND.n3521 3.396
R3784 GND.n3481 GND.n3479 3.396
R3785 GND.n3439 GND.n3437 3.396
R3786 GND.n3397 GND.n3395 3.396
R3787 GND.n3355 GND.n3353 3.396
R3788 GND.n3313 GND.n3311 3.396
R3789 GND.n3272 GND.n3270 3.396
R3790 GND.n4220 GND.n4218 3.396
R3791 GND.n4178 GND.n4176 3.396
R3792 GND.n4136 GND.n4134 3.396
R3793 GND.n4094 GND.n4092 3.396
R3794 GND.n4052 GND.n4050 3.396
R3795 GND.n4010 GND.n4008 3.396
R3796 GND.n3968 GND.n3966 3.396
R3797 GND.n3927 GND.n3925 3.396
R3798 GND.n4876 GND.n4874 3.396
R3799 GND.n4834 GND.n4832 3.396
R3800 GND.n4792 GND.n4790 3.396
R3801 GND.n4750 GND.n4748 3.396
R3802 GND.n4708 GND.n4706 3.396
R3803 GND.n4666 GND.n4664 3.396
R3804 GND.n4624 GND.n4622 3.396
R3805 GND.n4583 GND.n4581 3.396
R3806 GND.n70 GND.n69 3.324
R3807 GND.n243 GND.n242 3.324
R3808 GND.n202 GND.n201 3.324
R3809 GND.n171 GND.n170 3.324
R3810 GND.n162 GND.n161 3.324
R3811 GND.n131 GND.n130 3.324
R3812 GND.n122 GND.n121 3.324
R3813 GND.n581 GND.n580 3.324
R3814 GND.n539 GND.n538 3.324
R3815 GND.n497 GND.n496 3.324
R3816 GND.n456 GND.n455 3.324
R3817 GND.n425 GND.n424 3.324
R3818 GND.n416 GND.n415 3.324
R3819 GND.n385 GND.n384 3.324
R3820 GND.n376 GND.n375 3.324
R3821 GND.n345 GND.n344 3.324
R3822 GND.n336 GND.n335 3.324
R3823 GND.n305 GND.n304 3.324
R3824 GND.n296 GND.n295 3.324
R3825 GND.n1247 GND.n1246 3.324
R3826 GND.n1205 GND.n1204 3.324
R3827 GND.n1163 GND.n1162 3.324
R3828 GND.n1121 GND.n1120 3.324
R3829 GND.n1079 GND.n1078 3.324
R3830 GND.n1037 GND.n1036 3.324
R3831 GND.n995 GND.n994 3.324
R3832 GND.n954 GND.n953 3.324
R3833 GND.n923 GND.n922 3.324
R3834 GND.n914 GND.n913 3.324
R3835 GND.n883 GND.n882 3.324
R3836 GND.n874 GND.n873 3.324
R3837 GND.n843 GND.n842 3.324
R3838 GND.n834 GND.n833 3.324
R3839 GND.n803 GND.n802 3.324
R3840 GND.n794 GND.n793 3.324
R3841 GND.n763 GND.n762 3.324
R3842 GND.n754 GND.n753 3.324
R3843 GND.n723 GND.n722 3.324
R3844 GND.n714 GND.n713 3.324
R3845 GND.n683 GND.n682 3.324
R3846 GND.n674 GND.n673 3.324
R3847 GND.n643 GND.n642 3.324
R3848 GND.n634 GND.n633 3.324
R3849 GND.n2569 GND.n2568 3.324
R3850 GND.n2527 GND.n2526 3.324
R3851 GND.n2485 GND.n2484 3.324
R3852 GND.n2443 GND.n2442 3.324
R3853 GND.n2401 GND.n2400 3.324
R3854 GND.n2359 GND.n2358 3.324
R3855 GND.n2317 GND.n2316 3.324
R3856 GND.n2275 GND.n2274 3.324
R3857 GND.n2233 GND.n2232 3.324
R3858 GND.n2191 GND.n2190 3.324
R3859 GND.n2149 GND.n2148 3.324
R3860 GND.n2107 GND.n2106 3.324
R3861 GND.n2065 GND.n2064 3.324
R3862 GND.n2023 GND.n2022 3.324
R3863 GND.n1981 GND.n1980 3.324
R3864 GND.n1940 GND.n1939 3.324
R3865 GND.n1909 GND.n1908 3.324
R3866 GND.n1900 GND.n1899 3.324
R3867 GND.n1869 GND.n1868 3.324
R3868 GND.n1860 GND.n1859 3.324
R3869 GND.n1829 GND.n1828 3.324
R3870 GND.n1820 GND.n1819 3.324
R3871 GND.n1789 GND.n1788 3.324
R3872 GND.n1780 GND.n1779 3.324
R3873 GND.n1749 GND.n1748 3.324
R3874 GND.n1740 GND.n1739 3.324
R3875 GND.n1709 GND.n1708 3.324
R3876 GND.n1700 GND.n1699 3.324
R3877 GND.n1669 GND.n1668 3.324
R3878 GND.n1660 GND.n1659 3.324
R3879 GND.n1629 GND.n1628 3.324
R3880 GND.n1620 GND.n1619 3.324
R3881 GND.n1589 GND.n1588 3.324
R3882 GND.n1580 GND.n1579 3.324
R3883 GND.n1549 GND.n1548 3.324
R3884 GND.n1540 GND.n1539 3.324
R3885 GND.n1509 GND.n1508 3.324
R3886 GND.n1500 GND.n1499 3.324
R3887 GND.n1469 GND.n1468 3.324
R3888 GND.n1460 GND.n1459 3.324
R3889 GND.n1429 GND.n1428 3.324
R3890 GND.n1420 GND.n1419 3.324
R3891 GND.n1389 GND.n1388 3.324
R3892 GND.n1380 GND.n1379 3.324
R3893 GND.n1349 GND.n1348 3.324
R3894 GND.n1340 GND.n1339 3.324
R3895 GND.n1309 GND.n1308 3.324
R3896 GND.n1300 GND.n1299 3.324
R3897 GND.n5203 GND.n5202 3.324
R3898 GND.n5161 GND.n5160 3.324
R3899 GND.n5119 GND.n5118 3.324
R3900 GND.n5077 GND.n5076 3.324
R3901 GND.n5035 GND.n5034 3.324
R3902 GND.n4993 GND.n4992 3.324
R3903 GND.n4951 GND.n4950 3.324
R3904 GND.n4909 GND.n4908 3.324
R3905 GND.n3555 GND.n3554 3.324
R3906 GND.n3513 GND.n3512 3.324
R3907 GND.n3471 GND.n3470 3.324
R3908 GND.n3429 GND.n3428 3.324
R3909 GND.n3387 GND.n3386 3.324
R3910 GND.n3345 GND.n3344 3.324
R3911 GND.n3303 GND.n3302 3.324
R3912 GND.n3262 GND.n3261 3.324
R3913 GND.n3231 GND.n3230 3.324
R3914 GND.n3222 GND.n3221 3.324
R3915 GND.n3191 GND.n3190 3.324
R3916 GND.n3182 GND.n3181 3.324
R3917 GND.n3151 GND.n3150 3.324
R3918 GND.n3142 GND.n3141 3.324
R3919 GND.n3111 GND.n3110 3.324
R3920 GND.n3102 GND.n3101 3.324
R3921 GND.n3071 GND.n3070 3.324
R3922 GND.n3062 GND.n3061 3.324
R3923 GND.n3031 GND.n3030 3.324
R3924 GND.n3022 GND.n3021 3.324
R3925 GND.n2991 GND.n2990 3.324
R3926 GND.n2982 GND.n2981 3.324
R3927 GND.n2951 GND.n2950 3.324
R3928 GND.n2942 GND.n2941 3.324
R3929 GND.n4210 GND.n4209 3.324
R3930 GND.n4168 GND.n4167 3.324
R3931 GND.n4126 GND.n4125 3.324
R3932 GND.n4084 GND.n4083 3.324
R3933 GND.n4042 GND.n4041 3.324
R3934 GND.n4000 GND.n3999 3.324
R3935 GND.n3958 GND.n3957 3.324
R3936 GND.n3917 GND.n3916 3.324
R3937 GND.n3886 GND.n3885 3.324
R3938 GND.n3877 GND.n3876 3.324
R3939 GND.n3846 GND.n3845 3.324
R3940 GND.n3837 GND.n3836 3.324
R3941 GND.n3806 GND.n3805 3.324
R3942 GND.n3797 GND.n3796 3.324
R3943 GND.n3766 GND.n3765 3.324
R3944 GND.n3757 GND.n3756 3.324
R3945 GND.n3726 GND.n3725 3.324
R3946 GND.n3717 GND.n3716 3.324
R3947 GND.n3686 GND.n3685 3.324
R3948 GND.n3677 GND.n3676 3.324
R3949 GND.n3646 GND.n3645 3.324
R3950 GND.n3637 GND.n3636 3.324
R3951 GND.n3606 GND.n3605 3.324
R3952 GND.n3597 GND.n3596 3.324
R3953 GND.n4866 GND.n4865 3.324
R3954 GND.n4824 GND.n4823 3.324
R3955 GND.n4782 GND.n4781 3.324
R3956 GND.n4740 GND.n4739 3.324
R3957 GND.n4698 GND.n4697 3.324
R3958 GND.n4656 GND.n4655 3.324
R3959 GND.n4614 GND.n4613 3.324
R3960 GND.n4573 GND.n4572 3.324
R3961 GND.n4542 GND.n4541 3.324
R3962 GND.n4533 GND.n4532 3.324
R3963 GND.n4502 GND.n4501 3.324
R3964 GND.n4493 GND.n4492 3.324
R3965 GND.n4462 GND.n4461 3.324
R3966 GND.n4453 GND.n4452 3.324
R3967 GND.n4422 GND.n4421 3.324
R3968 GND.n4413 GND.n4412 3.324
R3969 GND.n4382 GND.n4381 3.324
R3970 GND.n4373 GND.n4372 3.324
R3971 GND.n4342 GND.n4341 3.324
R3972 GND.n4333 GND.n4332 3.324
R3973 GND.n4302 GND.n4301 3.324
R3974 GND.n4293 GND.n4292 3.324
R3975 GND.n4262 GND.n4261 3.324
R3976 GND.n4253 GND.n4252 3.324
R3977 GND.n2911 GND.n2910 3.324
R3978 GND.n2902 GND.n2901 3.324
R3979 GND.n2871 GND.n2870 3.324
R3980 GND.n2862 GND.n2861 3.324
R3981 GND.n2831 GND.n2830 3.324
R3982 GND.n2822 GND.n2821 3.324
R3983 GND.n2791 GND.n2790 3.324
R3984 GND.n2782 GND.n2781 3.324
R3985 GND.n2751 GND.n2750 3.324
R3986 GND.n2742 GND.n2741 3.324
R3987 GND.n2711 GND.n2710 3.324
R3988 GND.n2702 GND.n2701 3.324
R3989 GND.n2671 GND.n2670 3.324
R3990 GND.n2662 GND.n2661 3.324
R3991 GND.n2631 GND.n2630 3.324
R3992 GND.n2622 GND.n2621 3.324
R3993 GND.n4886 GND.n4230 3.142
R3994 GND GND.n5230 2.7
R3995 GND.n3 GND.n2 2.461
R3996 GND.n95 GND.n94 2.461
R3997 GND.n269 GND.n268 2.461
R3998 GND.n607 GND.n606 2.461
R3999 GND.n1273 GND.n1272 2.461
R4000 GND.n2595 GND.n2594 2.461
R4001 GND.n5230 GND.n5229 2.287
R4002 GND.n5229 GND.n5228 2.287
R4003 GND.n5228 GND.n5227 2.287
R4004 GND.n80 GND.n79 2.163
R4005 GND.n33 GND.n32 2.163
R4006 GND.n24 GND.n23 2.163
R4007 GND.n253 GND.n252 2.163
R4008 GND.n212 GND.n211 2.163
R4009 GND.n591 GND.n590 2.163
R4010 GND.n549 GND.n548 2.163
R4011 GND.n507 GND.n506 2.163
R4012 GND.n466 GND.n465 2.163
R4013 GND.n1257 GND.n1256 2.163
R4014 GND.n1215 GND.n1214 2.163
R4015 GND.n1173 GND.n1172 2.163
R4016 GND.n1131 GND.n1130 2.163
R4017 GND.n1089 GND.n1088 2.163
R4018 GND.n1047 GND.n1046 2.163
R4019 GND.n1005 GND.n1004 2.163
R4020 GND.n964 GND.n963 2.163
R4021 GND.n2579 GND.n2578 2.163
R4022 GND.n2537 GND.n2536 2.163
R4023 GND.n2495 GND.n2494 2.163
R4024 GND.n2453 GND.n2452 2.163
R4025 GND.n2411 GND.n2410 2.163
R4026 GND.n2369 GND.n2368 2.163
R4027 GND.n2327 GND.n2326 2.163
R4028 GND.n2285 GND.n2284 2.163
R4029 GND.n2243 GND.n2242 2.163
R4030 GND.n2201 GND.n2200 2.163
R4031 GND.n2159 GND.n2158 2.163
R4032 GND.n2117 GND.n2116 2.163
R4033 GND.n2075 GND.n2074 2.163
R4034 GND.n2033 GND.n2032 2.163
R4035 GND.n1991 GND.n1990 2.163
R4036 GND.n1950 GND.n1949 2.163
R4037 GND.n5213 GND.n5212 2.163
R4038 GND.n5171 GND.n5170 2.163
R4039 GND.n5129 GND.n5128 2.163
R4040 GND.n5087 GND.n5086 2.163
R4041 GND.n5045 GND.n5044 2.163
R4042 GND.n5003 GND.n5002 2.163
R4043 GND.n4961 GND.n4960 2.163
R4044 GND.n4919 GND.n4918 2.163
R4045 GND.n3565 GND.n3564 2.163
R4046 GND.n3523 GND.n3522 2.163
R4047 GND.n3481 GND.n3480 2.163
R4048 GND.n3439 GND.n3438 2.163
R4049 GND.n3397 GND.n3396 2.163
R4050 GND.n3355 GND.n3354 2.163
R4051 GND.n3313 GND.n3312 2.163
R4052 GND.n3272 GND.n3271 2.163
R4053 GND.n4220 GND.n4219 2.163
R4054 GND.n4178 GND.n4177 2.163
R4055 GND.n4136 GND.n4135 2.163
R4056 GND.n4094 GND.n4093 2.163
R4057 GND.n4052 GND.n4051 2.163
R4058 GND.n4010 GND.n4009 2.163
R4059 GND.n3968 GND.n3967 2.163
R4060 GND.n3927 GND.n3926 2.163
R4061 GND.n4876 GND.n4875 2.163
R4062 GND.n4834 GND.n4833 2.163
R4063 GND.n4792 GND.n4791 2.163
R4064 GND.n4750 GND.n4749 2.163
R4065 GND.n4708 GND.n4707 2.163
R4066 GND.n4666 GND.n4665 2.163
R4067 GND.n4624 GND.n4623 2.163
R4068 GND.n4583 GND.n4582 2.163
R4069 GND.n88 GND.n87 1.578
R4070 GND.n220 GND.n219 1.578
R4071 GND.n474 GND.n473 1.578
R4072 GND.n972 GND.n971 1.578
R4073 GND.n1958 GND.n1957 1.578
R4074 GND.n3280 GND.n3279 1.578
R4075 GND.n3935 GND.n3934 1.578
R4076 GND.n4591 GND.n4590 1.578
R4077 GND.n61 GND.n56 1.129
R4078 GND.n54 GND.n49 1.129
R4079 GND.n13 GND.n9 1.129
R4080 GND.n46 GND.n41 1.129
R4081 GND.n193 GND.n188 1.129
R4082 GND.n186 GND.n181 1.129
R4083 GND.n153 GND.n149 1.129
R4084 GND.n147 GND.n141 1.129
R4085 GND.n234 GND.n229 1.129
R4086 GND.n227 GND.n222 1.129
R4087 GND.n113 GND.n109 1.129
R4088 GND.n107 GND.n101 1.129
R4089 GND.n447 GND.n442 1.129
R4090 GND.n440 GND.n435 1.129
R4091 GND.n407 GND.n403 1.129
R4092 GND.n401 GND.n395 1.129
R4093 GND.n488 GND.n483 1.129
R4094 GND.n481 GND.n476 1.129
R4095 GND.n367 GND.n363 1.129
R4096 GND.n361 GND.n355 1.129
R4097 GND.n530 GND.n525 1.129
R4098 GND.n523 GND.n518 1.129
R4099 GND.n327 GND.n323 1.129
R4100 GND.n321 GND.n315 1.129
R4101 GND.n572 GND.n567 1.129
R4102 GND.n565 GND.n560 1.129
R4103 GND.n287 GND.n283 1.129
R4104 GND.n281 GND.n275 1.129
R4105 GND.n945 GND.n940 1.129
R4106 GND.n938 GND.n933 1.129
R4107 GND.n905 GND.n901 1.129
R4108 GND.n899 GND.n893 1.129
R4109 GND.n986 GND.n981 1.129
R4110 GND.n979 GND.n974 1.129
R4111 GND.n865 GND.n861 1.129
R4112 GND.n859 GND.n853 1.129
R4113 GND.n1028 GND.n1023 1.129
R4114 GND.n1021 GND.n1016 1.129
R4115 GND.n825 GND.n821 1.129
R4116 GND.n819 GND.n813 1.129
R4117 GND.n1070 GND.n1065 1.129
R4118 GND.n1063 GND.n1058 1.129
R4119 GND.n785 GND.n781 1.129
R4120 GND.n779 GND.n773 1.129
R4121 GND.n1112 GND.n1107 1.129
R4122 GND.n1105 GND.n1100 1.129
R4123 GND.n745 GND.n741 1.129
R4124 GND.n739 GND.n733 1.129
R4125 GND.n1154 GND.n1149 1.129
R4126 GND.n1147 GND.n1142 1.129
R4127 GND.n705 GND.n701 1.129
R4128 GND.n699 GND.n693 1.129
R4129 GND.n1196 GND.n1191 1.129
R4130 GND.n1189 GND.n1184 1.129
R4131 GND.n665 GND.n661 1.129
R4132 GND.n659 GND.n653 1.129
R4133 GND.n1238 GND.n1233 1.129
R4134 GND.n1231 GND.n1226 1.129
R4135 GND.n625 GND.n621 1.129
R4136 GND.n619 GND.n613 1.129
R4137 GND.n1931 GND.n1926 1.129
R4138 GND.n1924 GND.n1919 1.129
R4139 GND.n1891 GND.n1887 1.129
R4140 GND.n1885 GND.n1879 1.129
R4141 GND.n1972 GND.n1967 1.129
R4142 GND.n1965 GND.n1960 1.129
R4143 GND.n1851 GND.n1847 1.129
R4144 GND.n1845 GND.n1839 1.129
R4145 GND.n2014 GND.n2009 1.129
R4146 GND.n2007 GND.n2002 1.129
R4147 GND.n1811 GND.n1807 1.129
R4148 GND.n1805 GND.n1799 1.129
R4149 GND.n2056 GND.n2051 1.129
R4150 GND.n2049 GND.n2044 1.129
R4151 GND.n1771 GND.n1767 1.129
R4152 GND.n1765 GND.n1759 1.129
R4153 GND.n2098 GND.n2093 1.129
R4154 GND.n2091 GND.n2086 1.129
R4155 GND.n1731 GND.n1727 1.129
R4156 GND.n1725 GND.n1719 1.129
R4157 GND.n2140 GND.n2135 1.129
R4158 GND.n2133 GND.n2128 1.129
R4159 GND.n1691 GND.n1687 1.129
R4160 GND.n1685 GND.n1679 1.129
R4161 GND.n2182 GND.n2177 1.129
R4162 GND.n2175 GND.n2170 1.129
R4163 GND.n1651 GND.n1647 1.129
R4164 GND.n1645 GND.n1639 1.129
R4165 GND.n2224 GND.n2219 1.129
R4166 GND.n2217 GND.n2212 1.129
R4167 GND.n1611 GND.n1607 1.129
R4168 GND.n1605 GND.n1599 1.129
R4169 GND.n2266 GND.n2261 1.129
R4170 GND.n2259 GND.n2254 1.129
R4171 GND.n1571 GND.n1567 1.129
R4172 GND.n1565 GND.n1559 1.129
R4173 GND.n2308 GND.n2303 1.129
R4174 GND.n2301 GND.n2296 1.129
R4175 GND.n1531 GND.n1527 1.129
R4176 GND.n1525 GND.n1519 1.129
R4177 GND.n2350 GND.n2345 1.129
R4178 GND.n2343 GND.n2338 1.129
R4179 GND.n1491 GND.n1487 1.129
R4180 GND.n1485 GND.n1479 1.129
R4181 GND.n2392 GND.n2387 1.129
R4182 GND.n2385 GND.n2380 1.129
R4183 GND.n1451 GND.n1447 1.129
R4184 GND.n1445 GND.n1439 1.129
R4185 GND.n2434 GND.n2429 1.129
R4186 GND.n2427 GND.n2422 1.129
R4187 GND.n1411 GND.n1407 1.129
R4188 GND.n1405 GND.n1399 1.129
R4189 GND.n2476 GND.n2471 1.129
R4190 GND.n2469 GND.n2464 1.129
R4191 GND.n1371 GND.n1367 1.129
R4192 GND.n1365 GND.n1359 1.129
R4193 GND.n2518 GND.n2513 1.129
R4194 GND.n2511 GND.n2506 1.129
R4195 GND.n1331 GND.n1327 1.129
R4196 GND.n1325 GND.n1319 1.129
R4197 GND.n2560 GND.n2555 1.129
R4198 GND.n2553 GND.n2548 1.129
R4199 GND.n1291 GND.n1287 1.129
R4200 GND.n1285 GND.n1279 1.129
R4201 GND.n3253 GND.n3248 1.129
R4202 GND.n3246 GND.n3241 1.129
R4203 GND.n3213 GND.n3209 1.129
R4204 GND.n3207 GND.n3201 1.129
R4205 GND.n3294 GND.n3289 1.129
R4206 GND.n3287 GND.n3282 1.129
R4207 GND.n3173 GND.n3169 1.129
R4208 GND.n3167 GND.n3161 1.129
R4209 GND.n3336 GND.n3331 1.129
R4210 GND.n3329 GND.n3324 1.129
R4211 GND.n3133 GND.n3129 1.129
R4212 GND.n3127 GND.n3121 1.129
R4213 GND.n3378 GND.n3373 1.129
R4214 GND.n3371 GND.n3366 1.129
R4215 GND.n3093 GND.n3089 1.129
R4216 GND.n3087 GND.n3081 1.129
R4217 GND.n3420 GND.n3415 1.129
R4218 GND.n3413 GND.n3408 1.129
R4219 GND.n3053 GND.n3049 1.129
R4220 GND.n3047 GND.n3041 1.129
R4221 GND.n3462 GND.n3457 1.129
R4222 GND.n3455 GND.n3450 1.129
R4223 GND.n3013 GND.n3009 1.129
R4224 GND.n3007 GND.n3001 1.129
R4225 GND.n3504 GND.n3499 1.129
R4226 GND.n3497 GND.n3492 1.129
R4227 GND.n2973 GND.n2969 1.129
R4228 GND.n2967 GND.n2961 1.129
R4229 GND.n3546 GND.n3541 1.129
R4230 GND.n3539 GND.n3534 1.129
R4231 GND.n2933 GND.n2929 1.129
R4232 GND.n2927 GND.n2921 1.129
R4233 GND.n3908 GND.n3903 1.129
R4234 GND.n3901 GND.n3896 1.129
R4235 GND.n3868 GND.n3864 1.129
R4236 GND.n3862 GND.n3856 1.129
R4237 GND.n3949 GND.n3944 1.129
R4238 GND.n3942 GND.n3937 1.129
R4239 GND.n3828 GND.n3824 1.129
R4240 GND.n3822 GND.n3816 1.129
R4241 GND.n3991 GND.n3986 1.129
R4242 GND.n3984 GND.n3979 1.129
R4243 GND.n3788 GND.n3784 1.129
R4244 GND.n3782 GND.n3776 1.129
R4245 GND.n4033 GND.n4028 1.129
R4246 GND.n4026 GND.n4021 1.129
R4247 GND.n3748 GND.n3744 1.129
R4248 GND.n3742 GND.n3736 1.129
R4249 GND.n4075 GND.n4070 1.129
R4250 GND.n4068 GND.n4063 1.129
R4251 GND.n3708 GND.n3704 1.129
R4252 GND.n3702 GND.n3696 1.129
R4253 GND.n4117 GND.n4112 1.129
R4254 GND.n4110 GND.n4105 1.129
R4255 GND.n3668 GND.n3664 1.129
R4256 GND.n3662 GND.n3656 1.129
R4257 GND.n4159 GND.n4154 1.129
R4258 GND.n4152 GND.n4147 1.129
R4259 GND.n3628 GND.n3624 1.129
R4260 GND.n3622 GND.n3616 1.129
R4261 GND.n4201 GND.n4196 1.129
R4262 GND.n4194 GND.n4189 1.129
R4263 GND.n3588 GND.n3584 1.129
R4264 GND.n3582 GND.n3576 1.129
R4265 GND.n4564 GND.n4559 1.129
R4266 GND.n4557 GND.n4552 1.129
R4267 GND.n4524 GND.n4520 1.129
R4268 GND.n4518 GND.n4512 1.129
R4269 GND.n4605 GND.n4600 1.129
R4270 GND.n4598 GND.n4593 1.129
R4271 GND.n4484 GND.n4480 1.129
R4272 GND.n4478 GND.n4472 1.129
R4273 GND.n4647 GND.n4642 1.129
R4274 GND.n4640 GND.n4635 1.129
R4275 GND.n4444 GND.n4440 1.129
R4276 GND.n4438 GND.n4432 1.129
R4277 GND.n4689 GND.n4684 1.129
R4278 GND.n4682 GND.n4677 1.129
R4279 GND.n4404 GND.n4400 1.129
R4280 GND.n4398 GND.n4392 1.129
R4281 GND.n4731 GND.n4726 1.129
R4282 GND.n4724 GND.n4719 1.129
R4283 GND.n4364 GND.n4360 1.129
R4284 GND.n4358 GND.n4352 1.129
R4285 GND.n4773 GND.n4768 1.129
R4286 GND.n4766 GND.n4761 1.129
R4287 GND.n4324 GND.n4320 1.129
R4288 GND.n4318 GND.n4312 1.129
R4289 GND.n4815 GND.n4810 1.129
R4290 GND.n4808 GND.n4803 1.129
R4291 GND.n4284 GND.n4280 1.129
R4292 GND.n4278 GND.n4272 1.129
R4293 GND.n4857 GND.n4852 1.129
R4294 GND.n4850 GND.n4845 1.129
R4295 GND.n4244 GND.n4240 1.129
R4296 GND.n4238 GND.n4232 1.129
R4297 GND.n4900 GND.n4895 1.129
R4298 GND.n4893 GND.n4888 1.129
R4299 GND.n2893 GND.n2889 1.129
R4300 GND.n2887 GND.n2881 1.129
R4301 GND.n4942 GND.n4937 1.129
R4302 GND.n4935 GND.n4930 1.129
R4303 GND.n2853 GND.n2849 1.129
R4304 GND.n2847 GND.n2841 1.129
R4305 GND.n4984 GND.n4979 1.129
R4306 GND.n4977 GND.n4972 1.129
R4307 GND.n2813 GND.n2809 1.129
R4308 GND.n2807 GND.n2801 1.129
R4309 GND.n5026 GND.n5021 1.129
R4310 GND.n5019 GND.n5014 1.129
R4311 GND.n2773 GND.n2769 1.129
R4312 GND.n2767 GND.n2761 1.129
R4313 GND.n5068 GND.n5063 1.129
R4314 GND.n5061 GND.n5056 1.129
R4315 GND.n2733 GND.n2729 1.129
R4316 GND.n2727 GND.n2721 1.129
R4317 GND.n5110 GND.n5105 1.129
R4318 GND.n5103 GND.n5098 1.129
R4319 GND.n2693 GND.n2689 1.129
R4320 GND.n2687 GND.n2681 1.129
R4321 GND.n5152 GND.n5147 1.129
R4322 GND.n5145 GND.n5140 1.129
R4323 GND.n2653 GND.n2649 1.129
R4324 GND.n2647 GND.n2641 1.129
R4325 GND.n5194 GND.n5189 1.129
R4326 GND.n5187 GND.n5182 1.129
R4327 GND.n2613 GND.n2609 1.129
R4328 GND.n2607 GND.n2601 1.129
R4329 GND.n88 GND.n47 0.843
R4330 GND.n220 GND.n179 0.843
R4331 GND.n261 GND.n260 0.843
R4332 GND.n262 GND.n139 0.843
R4333 GND.n474 GND.n433 0.843
R4334 GND.n515 GND.n514 0.843
R4335 GND.n516 GND.n393 0.843
R4336 GND.n557 GND.n556 0.843
R4337 GND.n558 GND.n353 0.843
R4338 GND.n599 GND.n598 0.843
R4339 GND.n600 GND.n313 0.843
R4340 GND.n972 GND.n931 0.843
R4341 GND.n1013 GND.n1012 0.843
R4342 GND.n1014 GND.n891 0.843
R4343 GND.n1055 GND.n1054 0.843
R4344 GND.n1056 GND.n851 0.843
R4345 GND.n1097 GND.n1096 0.843
R4346 GND.n1098 GND.n811 0.843
R4347 GND.n1139 GND.n1138 0.843
R4348 GND.n1140 GND.n771 0.843
R4349 GND.n1181 GND.n1180 0.843
R4350 GND.n1182 GND.n731 0.843
R4351 GND.n1223 GND.n1222 0.843
R4352 GND.n1224 GND.n691 0.843
R4353 GND.n1265 GND.n1264 0.843
R4354 GND.n1266 GND.n651 0.843
R4355 GND.n1958 GND.n1917 0.843
R4356 GND.n1999 GND.n1998 0.843
R4357 GND.n2000 GND.n1877 0.843
R4358 GND.n2041 GND.n2040 0.843
R4359 GND.n2042 GND.n1837 0.843
R4360 GND.n2083 GND.n2082 0.843
R4361 GND.n2084 GND.n1797 0.843
R4362 GND.n2125 GND.n2124 0.843
R4363 GND.n2126 GND.n1757 0.843
R4364 GND.n2167 GND.n2166 0.843
R4365 GND.n2168 GND.n1717 0.843
R4366 GND.n2209 GND.n2208 0.843
R4367 GND.n2210 GND.n1677 0.843
R4368 GND.n2251 GND.n2250 0.843
R4369 GND.n2252 GND.n1637 0.843
R4370 GND.n2293 GND.n2292 0.843
R4371 GND.n2294 GND.n1597 0.843
R4372 GND.n2335 GND.n2334 0.843
R4373 GND.n2336 GND.n1557 0.843
R4374 GND.n2377 GND.n2376 0.843
R4375 GND.n2378 GND.n1517 0.843
R4376 GND.n2419 GND.n2418 0.843
R4377 GND.n2420 GND.n1477 0.843
R4378 GND.n2461 GND.n2460 0.843
R4379 GND.n2462 GND.n1437 0.843
R4380 GND.n2503 GND.n2502 0.843
R4381 GND.n2504 GND.n1397 0.843
R4382 GND.n2545 GND.n2544 0.843
R4383 GND.n2546 GND.n1357 0.843
R4384 GND.n2587 GND.n2586 0.843
R4385 GND.n2588 GND.n1317 0.843
R4386 GND.n3280 GND.n3239 0.843
R4387 GND.n3321 GND.n3320 0.843
R4388 GND.n3322 GND.n3199 0.843
R4389 GND.n3363 GND.n3362 0.843
R4390 GND.n3364 GND.n3159 0.843
R4391 GND.n3405 GND.n3404 0.843
R4392 GND.n3406 GND.n3119 0.843
R4393 GND.n3447 GND.n3446 0.843
R4394 GND.n3448 GND.n3079 0.843
R4395 GND.n3489 GND.n3488 0.843
R4396 GND.n3490 GND.n3039 0.843
R4397 GND.n3531 GND.n3530 0.843
R4398 GND.n3532 GND.n2999 0.843
R4399 GND.n3573 GND.n3572 0.843
R4400 GND.n3574 GND.n2959 0.843
R4401 GND.n3935 GND.n3894 0.843
R4402 GND.n3976 GND.n3975 0.843
R4403 GND.n3977 GND.n3854 0.843
R4404 GND.n4018 GND.n4017 0.843
R4405 GND.n4019 GND.n3814 0.843
R4406 GND.n4060 GND.n4059 0.843
R4407 GND.n4061 GND.n3774 0.843
R4408 GND.n4102 GND.n4101 0.843
R4409 GND.n4103 GND.n3734 0.843
R4410 GND.n4144 GND.n4143 0.843
R4411 GND.n4145 GND.n3694 0.843
R4412 GND.n4186 GND.n4185 0.843
R4413 GND.n4187 GND.n3654 0.843
R4414 GND.n4228 GND.n4227 0.843
R4415 GND.n4229 GND.n3614 0.843
R4416 GND.n4591 GND.n4550 0.843
R4417 GND.n4632 GND.n4631 0.843
R4418 GND.n4633 GND.n4510 0.843
R4419 GND.n4674 GND.n4673 0.843
R4420 GND.n4675 GND.n4470 0.843
R4421 GND.n4716 GND.n4715 0.843
R4422 GND.n4717 GND.n4430 0.843
R4423 GND.n4758 GND.n4757 0.843
R4424 GND.n4759 GND.n4390 0.843
R4425 GND.n4800 GND.n4799 0.843
R4426 GND.n4801 GND.n4350 0.843
R4427 GND.n4842 GND.n4841 0.843
R4428 GND.n4843 GND.n4310 0.843
R4429 GND.n4884 GND.n4883 0.843
R4430 GND.n4885 GND.n4270 0.843
R4431 GND.n4927 GND.n4926 0.843
R4432 GND.n4928 GND.n2919 0.843
R4433 GND.n4969 GND.n4968 0.843
R4434 GND.n4970 GND.n2879 0.843
R4435 GND.n5011 GND.n5010 0.843
R4436 GND.n5012 GND.n2839 0.843
R4437 GND.n5053 GND.n5052 0.843
R4438 GND.n5054 GND.n2799 0.843
R4439 GND.n5095 GND.n5094 0.843
R4440 GND.n5096 GND.n2759 0.843
R4441 GND.n5137 GND.n5136 0.843
R4442 GND.n5138 GND.n2719 0.843
R4443 GND.n5179 GND.n5178 0.843
R4444 GND.n5180 GND.n2679 0.843
R4445 GND.n5221 GND.n5220 0.843
R4446 GND.n5222 GND.n2639 0.843
R4447 GND.n262 GND.n261 0.763
R4448 GND.n600 GND.n599 0.763
R4449 GND.n558 GND.n557 0.763
R4450 GND.n516 GND.n515 0.763
R4451 GND.n1266 GND.n1265 0.763
R4452 GND.n1224 GND.n1223 0.763
R4453 GND.n1182 GND.n1181 0.763
R4454 GND.n1140 GND.n1139 0.763
R4455 GND.n1098 GND.n1097 0.763
R4456 GND.n1056 GND.n1055 0.763
R4457 GND.n1014 GND.n1013 0.763
R4458 GND.n2588 GND.n2587 0.763
R4459 GND.n2546 GND.n2545 0.763
R4460 GND.n2504 GND.n2503 0.763
R4461 GND.n2462 GND.n2461 0.763
R4462 GND.n2420 GND.n2419 0.763
R4463 GND.n2378 GND.n2377 0.763
R4464 GND.n2336 GND.n2335 0.763
R4465 GND.n2294 GND.n2293 0.763
R4466 GND.n2252 GND.n2251 0.763
R4467 GND.n2210 GND.n2209 0.763
R4468 GND.n2168 GND.n2167 0.763
R4469 GND.n2126 GND.n2125 0.763
R4470 GND.n2084 GND.n2083 0.763
R4471 GND.n2042 GND.n2041 0.763
R4472 GND.n2000 GND.n1999 0.763
R4473 GND.n5222 GND.n5221 0.763
R4474 GND.n5180 GND.n5179 0.763
R4475 GND.n5138 GND.n5137 0.763
R4476 GND.n5096 GND.n5095 0.763
R4477 GND.n5054 GND.n5053 0.763
R4478 GND.n5012 GND.n5011 0.763
R4479 GND.n4970 GND.n4969 0.763
R4480 GND.n4928 GND.n4927 0.763
R4481 GND.n3574 GND.n3573 0.763
R4482 GND.n3532 GND.n3531 0.763
R4483 GND.n3490 GND.n3489 0.763
R4484 GND.n3448 GND.n3447 0.763
R4485 GND.n3406 GND.n3405 0.763
R4486 GND.n3364 GND.n3363 0.763
R4487 GND.n3322 GND.n3321 0.763
R4488 GND.n4229 GND.n4228 0.763
R4489 GND.n4187 GND.n4186 0.763
R4490 GND.n4145 GND.n4144 0.763
R4491 GND.n4103 GND.n4102 0.763
R4492 GND.n4061 GND.n4060 0.763
R4493 GND.n4019 GND.n4018 0.763
R4494 GND.n3977 GND.n3976 0.763
R4495 GND.n4885 GND.n4884 0.763
R4496 GND.n4843 GND.n4842 0.763
R4497 GND.n4801 GND.n4800 0.763
R4498 GND.n4759 GND.n4758 0.763
R4499 GND.n4717 GND.n4716 0.763
R4500 GND.n4675 GND.n4674 0.763
R4501 GND.n4633 GND.n4632 0.763
R4502 GND.n5230 GND.n91 0.678
R4503 GND.n5229 GND.n265 0.678
R4504 GND.n5228 GND.n603 0.678
R4505 GND.n5227 GND.n1269 0.678
R4506 GND.n5226 GND.n2591 0.678
R4507 GND.n3 GND.n1 0.656
R4508 GND.n95 GND.n93 0.656
R4509 GND.n269 GND.n267 0.656
R4510 GND.n607 GND.n605 0.656
R4511 GND.n1273 GND.n1271 0.656
R4512 GND.n2595 GND.n2593 0.656
R4513 GND.n72 GND.n67 0.376
R4514 GND.n81 GND.n75 0.376
R4515 GND.n25 GND.n19 0.376
R4516 GND.n34 GND.n28 0.376
R4517 GND.n204 GND.n199 0.376
R4518 GND.n213 GND.n207 0.376
R4519 GND.n164 GND.n159 0.376
R4520 GND.n173 GND.n167 0.376
R4521 GND.n245 GND.n240 0.376
R4522 GND.n254 GND.n248 0.376
R4523 GND.n124 GND.n119 0.376
R4524 GND.n133 GND.n127 0.376
R4525 GND.n458 GND.n453 0.376
R4526 GND.n467 GND.n461 0.376
R4527 GND.n418 GND.n413 0.376
R4528 GND.n427 GND.n421 0.376
R4529 GND.n499 GND.n494 0.376
R4530 GND.n508 GND.n502 0.376
R4531 GND.n378 GND.n373 0.376
R4532 GND.n387 GND.n381 0.376
R4533 GND.n541 GND.n536 0.376
R4534 GND.n550 GND.n544 0.376
R4535 GND.n338 GND.n333 0.376
R4536 GND.n347 GND.n341 0.376
R4537 GND.n583 GND.n578 0.376
R4538 GND.n592 GND.n586 0.376
R4539 GND.n298 GND.n293 0.376
R4540 GND.n307 GND.n301 0.376
R4541 GND.n956 GND.n951 0.376
R4542 GND.n965 GND.n959 0.376
R4543 GND.n916 GND.n911 0.376
R4544 GND.n925 GND.n919 0.376
R4545 GND.n997 GND.n992 0.376
R4546 GND.n1006 GND.n1000 0.376
R4547 GND.n876 GND.n871 0.376
R4548 GND.n885 GND.n879 0.376
R4549 GND.n1039 GND.n1034 0.376
R4550 GND.n1048 GND.n1042 0.376
R4551 GND.n836 GND.n831 0.376
R4552 GND.n845 GND.n839 0.376
R4553 GND.n1081 GND.n1076 0.376
R4554 GND.n1090 GND.n1084 0.376
R4555 GND.n796 GND.n791 0.376
R4556 GND.n805 GND.n799 0.376
R4557 GND.n1123 GND.n1118 0.376
R4558 GND.n1132 GND.n1126 0.376
R4559 GND.n756 GND.n751 0.376
R4560 GND.n765 GND.n759 0.376
R4561 GND.n1165 GND.n1160 0.376
R4562 GND.n1174 GND.n1168 0.376
R4563 GND.n716 GND.n711 0.376
R4564 GND.n725 GND.n719 0.376
R4565 GND.n1207 GND.n1202 0.376
R4566 GND.n1216 GND.n1210 0.376
R4567 GND.n676 GND.n671 0.376
R4568 GND.n685 GND.n679 0.376
R4569 GND.n1249 GND.n1244 0.376
R4570 GND.n1258 GND.n1252 0.376
R4571 GND.n636 GND.n631 0.376
R4572 GND.n645 GND.n639 0.376
R4573 GND.n1942 GND.n1937 0.376
R4574 GND.n1951 GND.n1945 0.376
R4575 GND.n1902 GND.n1897 0.376
R4576 GND.n1911 GND.n1905 0.376
R4577 GND.n1983 GND.n1978 0.376
R4578 GND.n1992 GND.n1986 0.376
R4579 GND.n1862 GND.n1857 0.376
R4580 GND.n1871 GND.n1865 0.376
R4581 GND.n2025 GND.n2020 0.376
R4582 GND.n2034 GND.n2028 0.376
R4583 GND.n1822 GND.n1817 0.376
R4584 GND.n1831 GND.n1825 0.376
R4585 GND.n2067 GND.n2062 0.376
R4586 GND.n2076 GND.n2070 0.376
R4587 GND.n1782 GND.n1777 0.376
R4588 GND.n1791 GND.n1785 0.376
R4589 GND.n2109 GND.n2104 0.376
R4590 GND.n2118 GND.n2112 0.376
R4591 GND.n1742 GND.n1737 0.376
R4592 GND.n1751 GND.n1745 0.376
R4593 GND.n2151 GND.n2146 0.376
R4594 GND.n2160 GND.n2154 0.376
R4595 GND.n1702 GND.n1697 0.376
R4596 GND.n1711 GND.n1705 0.376
R4597 GND.n2193 GND.n2188 0.376
R4598 GND.n2202 GND.n2196 0.376
R4599 GND.n1662 GND.n1657 0.376
R4600 GND.n1671 GND.n1665 0.376
R4601 GND.n2235 GND.n2230 0.376
R4602 GND.n2244 GND.n2238 0.376
R4603 GND.n1622 GND.n1617 0.376
R4604 GND.n1631 GND.n1625 0.376
R4605 GND.n2277 GND.n2272 0.376
R4606 GND.n2286 GND.n2280 0.376
R4607 GND.n1582 GND.n1577 0.376
R4608 GND.n1591 GND.n1585 0.376
R4609 GND.n2319 GND.n2314 0.376
R4610 GND.n2328 GND.n2322 0.376
R4611 GND.n1542 GND.n1537 0.376
R4612 GND.n1551 GND.n1545 0.376
R4613 GND.n2361 GND.n2356 0.376
R4614 GND.n2370 GND.n2364 0.376
R4615 GND.n1502 GND.n1497 0.376
R4616 GND.n1511 GND.n1505 0.376
R4617 GND.n2403 GND.n2398 0.376
R4618 GND.n2412 GND.n2406 0.376
R4619 GND.n1462 GND.n1457 0.376
R4620 GND.n1471 GND.n1465 0.376
R4621 GND.n2445 GND.n2440 0.376
R4622 GND.n2454 GND.n2448 0.376
R4623 GND.n1422 GND.n1417 0.376
R4624 GND.n1431 GND.n1425 0.376
R4625 GND.n2487 GND.n2482 0.376
R4626 GND.n2496 GND.n2490 0.376
R4627 GND.n1382 GND.n1377 0.376
R4628 GND.n1391 GND.n1385 0.376
R4629 GND.n2529 GND.n2524 0.376
R4630 GND.n2538 GND.n2532 0.376
R4631 GND.n1342 GND.n1337 0.376
R4632 GND.n1351 GND.n1345 0.376
R4633 GND.n2571 GND.n2566 0.376
R4634 GND.n2580 GND.n2574 0.376
R4635 GND.n1302 GND.n1297 0.376
R4636 GND.n1311 GND.n1305 0.376
R4637 GND.n3264 GND.n3259 0.376
R4638 GND.n3273 GND.n3267 0.376
R4639 GND.n3224 GND.n3219 0.376
R4640 GND.n3233 GND.n3227 0.376
R4641 GND.n3305 GND.n3300 0.376
R4642 GND.n3314 GND.n3308 0.376
R4643 GND.n3184 GND.n3179 0.376
R4644 GND.n3193 GND.n3187 0.376
R4645 GND.n3347 GND.n3342 0.376
R4646 GND.n3356 GND.n3350 0.376
R4647 GND.n3144 GND.n3139 0.376
R4648 GND.n3153 GND.n3147 0.376
R4649 GND.n3389 GND.n3384 0.376
R4650 GND.n3398 GND.n3392 0.376
R4651 GND.n3104 GND.n3099 0.376
R4652 GND.n3113 GND.n3107 0.376
R4653 GND.n3431 GND.n3426 0.376
R4654 GND.n3440 GND.n3434 0.376
R4655 GND.n3064 GND.n3059 0.376
R4656 GND.n3073 GND.n3067 0.376
R4657 GND.n3473 GND.n3468 0.376
R4658 GND.n3482 GND.n3476 0.376
R4659 GND.n3024 GND.n3019 0.376
R4660 GND.n3033 GND.n3027 0.376
R4661 GND.n3515 GND.n3510 0.376
R4662 GND.n3524 GND.n3518 0.376
R4663 GND.n2984 GND.n2979 0.376
R4664 GND.n2993 GND.n2987 0.376
R4665 GND.n3557 GND.n3552 0.376
R4666 GND.n3566 GND.n3560 0.376
R4667 GND.n2944 GND.n2939 0.376
R4668 GND.n2953 GND.n2947 0.376
R4669 GND.n3919 GND.n3914 0.376
R4670 GND.n3928 GND.n3922 0.376
R4671 GND.n3879 GND.n3874 0.376
R4672 GND.n3888 GND.n3882 0.376
R4673 GND.n3960 GND.n3955 0.376
R4674 GND.n3969 GND.n3963 0.376
R4675 GND.n3839 GND.n3834 0.376
R4676 GND.n3848 GND.n3842 0.376
R4677 GND.n4002 GND.n3997 0.376
R4678 GND.n4011 GND.n4005 0.376
R4679 GND.n3799 GND.n3794 0.376
R4680 GND.n3808 GND.n3802 0.376
R4681 GND.n4044 GND.n4039 0.376
R4682 GND.n4053 GND.n4047 0.376
R4683 GND.n3759 GND.n3754 0.376
R4684 GND.n3768 GND.n3762 0.376
R4685 GND.n4086 GND.n4081 0.376
R4686 GND.n4095 GND.n4089 0.376
R4687 GND.n3719 GND.n3714 0.376
R4688 GND.n3728 GND.n3722 0.376
R4689 GND.n4128 GND.n4123 0.376
R4690 GND.n4137 GND.n4131 0.376
R4691 GND.n3679 GND.n3674 0.376
R4692 GND.n3688 GND.n3682 0.376
R4693 GND.n4170 GND.n4165 0.376
R4694 GND.n4179 GND.n4173 0.376
R4695 GND.n3639 GND.n3634 0.376
R4696 GND.n3648 GND.n3642 0.376
R4697 GND.n4212 GND.n4207 0.376
R4698 GND.n4221 GND.n4215 0.376
R4699 GND.n3599 GND.n3594 0.376
R4700 GND.n3608 GND.n3602 0.376
R4701 GND.n4575 GND.n4570 0.376
R4702 GND.n4584 GND.n4578 0.376
R4703 GND.n4535 GND.n4530 0.376
R4704 GND.n4544 GND.n4538 0.376
R4705 GND.n4616 GND.n4611 0.376
R4706 GND.n4625 GND.n4619 0.376
R4707 GND.n4495 GND.n4490 0.376
R4708 GND.n4504 GND.n4498 0.376
R4709 GND.n4658 GND.n4653 0.376
R4710 GND.n4667 GND.n4661 0.376
R4711 GND.n4455 GND.n4450 0.376
R4712 GND.n4464 GND.n4458 0.376
R4713 GND.n4700 GND.n4695 0.376
R4714 GND.n4709 GND.n4703 0.376
R4715 GND.n4415 GND.n4410 0.376
R4716 GND.n4424 GND.n4418 0.376
R4717 GND.n4742 GND.n4737 0.376
R4718 GND.n4751 GND.n4745 0.376
R4719 GND.n4375 GND.n4370 0.376
R4720 GND.n4384 GND.n4378 0.376
R4721 GND.n4784 GND.n4779 0.376
R4722 GND.n4793 GND.n4787 0.376
R4723 GND.n4335 GND.n4330 0.376
R4724 GND.n4344 GND.n4338 0.376
R4725 GND.n4826 GND.n4821 0.376
R4726 GND.n4835 GND.n4829 0.376
R4727 GND.n4295 GND.n4290 0.376
R4728 GND.n4304 GND.n4298 0.376
R4729 GND.n4868 GND.n4863 0.376
R4730 GND.n4877 GND.n4871 0.376
R4731 GND.n4255 GND.n4250 0.376
R4732 GND.n4264 GND.n4258 0.376
R4733 GND.n4911 GND.n4906 0.376
R4734 GND.n4920 GND.n4914 0.376
R4735 GND.n2904 GND.n2899 0.376
R4736 GND.n2913 GND.n2907 0.376
R4737 GND.n4953 GND.n4948 0.376
R4738 GND.n4962 GND.n4956 0.376
R4739 GND.n2864 GND.n2859 0.376
R4740 GND.n2873 GND.n2867 0.376
R4741 GND.n4995 GND.n4990 0.376
R4742 GND.n5004 GND.n4998 0.376
R4743 GND.n2824 GND.n2819 0.376
R4744 GND.n2833 GND.n2827 0.376
R4745 GND.n5037 GND.n5032 0.376
R4746 GND.n5046 GND.n5040 0.376
R4747 GND.n2784 GND.n2779 0.376
R4748 GND.n2793 GND.n2787 0.376
R4749 GND.n5079 GND.n5074 0.376
R4750 GND.n5088 GND.n5082 0.376
R4751 GND.n2744 GND.n2739 0.376
R4752 GND.n2753 GND.n2747 0.376
R4753 GND.n5121 GND.n5116 0.376
R4754 GND.n5130 GND.n5124 0.376
R4755 GND.n2704 GND.n2699 0.376
R4756 GND.n2713 GND.n2707 0.376
R4757 GND.n5163 GND.n5158 0.376
R4758 GND.n5172 GND.n5166 0.376
R4759 GND.n2664 GND.n2659 0.376
R4760 GND.n2673 GND.n2667 0.376
R4761 GND.n5205 GND.n5200 0.376
R4762 GND.n5214 GND.n5208 0.376
R4763 GND.n2624 GND.n2619 0.376
R4764 GND.n2633 GND.n2627 0.376
R4765 GND.n90 GND.n89 0.16
R4766 GND.n264 GND.n263 0.16
R4767 GND.n602 GND.n601 0.16
R4768 GND.n1268 GND.n1267 0.16
R4769 GND.n2590 GND.n2589 0.16
R4770 GND.n5224 GND.n5223 0.16
R4771 GND.n4 GND.n3 0.152
R4772 GND.n96 GND.n95 0.152
R4773 GND.n270 GND.n269 0.152
R4774 GND.n608 GND.n607 0.152
R4775 GND.n1274 GND.n1273 0.152
R4776 GND.n2596 GND.n2595 0.152
R4777 GND.n82 GND.n73 0.15
R4778 GND.n35 GND.n26 0.15
R4779 GND.n214 GND.n205 0.15
R4780 GND.n174 GND.n165 0.15
R4781 GND.n255 GND.n246 0.15
R4782 GND.n134 GND.n125 0.15
R4783 GND.n468 GND.n459 0.15
R4784 GND.n428 GND.n419 0.15
R4785 GND.n509 GND.n500 0.15
R4786 GND.n388 GND.n379 0.15
R4787 GND.n551 GND.n542 0.15
R4788 GND.n348 GND.n339 0.15
R4789 GND.n593 GND.n584 0.15
R4790 GND.n308 GND.n299 0.15
R4791 GND.n966 GND.n957 0.15
R4792 GND.n926 GND.n917 0.15
R4793 GND.n1007 GND.n998 0.15
R4794 GND.n886 GND.n877 0.15
R4795 GND.n1049 GND.n1040 0.15
R4796 GND.n846 GND.n837 0.15
R4797 GND.n1091 GND.n1082 0.15
R4798 GND.n806 GND.n797 0.15
R4799 GND.n1133 GND.n1124 0.15
R4800 GND.n766 GND.n757 0.15
R4801 GND.n1175 GND.n1166 0.15
R4802 GND.n726 GND.n717 0.15
R4803 GND.n1217 GND.n1208 0.15
R4804 GND.n686 GND.n677 0.15
R4805 GND.n1259 GND.n1250 0.15
R4806 GND.n646 GND.n637 0.15
R4807 GND.n1952 GND.n1943 0.15
R4808 GND.n1912 GND.n1903 0.15
R4809 GND.n1993 GND.n1984 0.15
R4810 GND.n1872 GND.n1863 0.15
R4811 GND.n2035 GND.n2026 0.15
R4812 GND.n1832 GND.n1823 0.15
R4813 GND.n2077 GND.n2068 0.15
R4814 GND.n1792 GND.n1783 0.15
R4815 GND.n2119 GND.n2110 0.15
R4816 GND.n1752 GND.n1743 0.15
R4817 GND.n2161 GND.n2152 0.15
R4818 GND.n1712 GND.n1703 0.15
R4819 GND.n2203 GND.n2194 0.15
R4820 GND.n1672 GND.n1663 0.15
R4821 GND.n2245 GND.n2236 0.15
R4822 GND.n1632 GND.n1623 0.15
R4823 GND.n2287 GND.n2278 0.15
R4824 GND.n1592 GND.n1583 0.15
R4825 GND.n2329 GND.n2320 0.15
R4826 GND.n1552 GND.n1543 0.15
R4827 GND.n2371 GND.n2362 0.15
R4828 GND.n1512 GND.n1503 0.15
R4829 GND.n2413 GND.n2404 0.15
R4830 GND.n1472 GND.n1463 0.15
R4831 GND.n2455 GND.n2446 0.15
R4832 GND.n1432 GND.n1423 0.15
R4833 GND.n2497 GND.n2488 0.15
R4834 GND.n1392 GND.n1383 0.15
R4835 GND.n2539 GND.n2530 0.15
R4836 GND.n1352 GND.n1343 0.15
R4837 GND.n2581 GND.n2572 0.15
R4838 GND.n1312 GND.n1303 0.15
R4839 GND.n3274 GND.n3265 0.15
R4840 GND.n3234 GND.n3225 0.15
R4841 GND.n3315 GND.n3306 0.15
R4842 GND.n3194 GND.n3185 0.15
R4843 GND.n3357 GND.n3348 0.15
R4844 GND.n3154 GND.n3145 0.15
R4845 GND.n3399 GND.n3390 0.15
R4846 GND.n3114 GND.n3105 0.15
R4847 GND.n3441 GND.n3432 0.15
R4848 GND.n3074 GND.n3065 0.15
R4849 GND.n3483 GND.n3474 0.15
R4850 GND.n3034 GND.n3025 0.15
R4851 GND.n3525 GND.n3516 0.15
R4852 GND.n2994 GND.n2985 0.15
R4853 GND.n3567 GND.n3558 0.15
R4854 GND.n2954 GND.n2945 0.15
R4855 GND.n3929 GND.n3920 0.15
R4856 GND.n3889 GND.n3880 0.15
R4857 GND.n3970 GND.n3961 0.15
R4858 GND.n3849 GND.n3840 0.15
R4859 GND.n4012 GND.n4003 0.15
R4860 GND.n3809 GND.n3800 0.15
R4861 GND.n4054 GND.n4045 0.15
R4862 GND.n3769 GND.n3760 0.15
R4863 GND.n4096 GND.n4087 0.15
R4864 GND.n3729 GND.n3720 0.15
R4865 GND.n4138 GND.n4129 0.15
R4866 GND.n3689 GND.n3680 0.15
R4867 GND.n4180 GND.n4171 0.15
R4868 GND.n3649 GND.n3640 0.15
R4869 GND.n4222 GND.n4213 0.15
R4870 GND.n3609 GND.n3600 0.15
R4871 GND.n4585 GND.n4576 0.15
R4872 GND.n4545 GND.n4536 0.15
R4873 GND.n4626 GND.n4617 0.15
R4874 GND.n4505 GND.n4496 0.15
R4875 GND.n4668 GND.n4659 0.15
R4876 GND.n4465 GND.n4456 0.15
R4877 GND.n4710 GND.n4701 0.15
R4878 GND.n4425 GND.n4416 0.15
R4879 GND.n4752 GND.n4743 0.15
R4880 GND.n4385 GND.n4376 0.15
R4881 GND.n4794 GND.n4785 0.15
R4882 GND.n4345 GND.n4336 0.15
R4883 GND.n4836 GND.n4827 0.15
R4884 GND.n4305 GND.n4296 0.15
R4885 GND.n4878 GND.n4869 0.15
R4886 GND.n4265 GND.n4256 0.15
R4887 GND.n4921 GND.n4912 0.15
R4888 GND.n2914 GND.n2905 0.15
R4889 GND.n4963 GND.n4954 0.15
R4890 GND.n2874 GND.n2865 0.15
R4891 GND.n5005 GND.n4996 0.15
R4892 GND.n2834 GND.n2825 0.15
R4893 GND.n5047 GND.n5038 0.15
R4894 GND.n2794 GND.n2785 0.15
R4895 GND.n5089 GND.n5080 0.15
R4896 GND.n2754 GND.n2745 0.15
R4897 GND.n5131 GND.n5122 0.15
R4898 GND.n2714 GND.n2705 0.15
R4899 GND.n5173 GND.n5164 0.15
R4900 GND.n2674 GND.n2665 0.15
R4901 GND.n5215 GND.n5206 0.15
R4902 GND.n2634 GND.n2625 0.15
R4903 GND.n87 GND.n86 0.125
R4904 GND.n47 GND.n39 0.125
R4905 GND.n219 GND.n218 0.125
R4906 GND.n179 GND.n178 0.125
R4907 GND.n260 GND.n259 0.125
R4908 GND.n139 GND.n138 0.125
R4909 GND.n473 GND.n472 0.125
R4910 GND.n433 GND.n432 0.125
R4911 GND.n514 GND.n513 0.125
R4912 GND.n393 GND.n392 0.125
R4913 GND.n556 GND.n555 0.125
R4914 GND.n353 GND.n352 0.125
R4915 GND.n598 GND.n597 0.125
R4916 GND.n313 GND.n312 0.125
R4917 GND.n971 GND.n970 0.125
R4918 GND.n931 GND.n930 0.125
R4919 GND.n1012 GND.n1011 0.125
R4920 GND.n891 GND.n890 0.125
R4921 GND.n1054 GND.n1053 0.125
R4922 GND.n851 GND.n850 0.125
R4923 GND.n1096 GND.n1095 0.125
R4924 GND.n811 GND.n810 0.125
R4925 GND.n1138 GND.n1137 0.125
R4926 GND.n771 GND.n770 0.125
R4927 GND.n1180 GND.n1179 0.125
R4928 GND.n731 GND.n730 0.125
R4929 GND.n1222 GND.n1221 0.125
R4930 GND.n691 GND.n690 0.125
R4931 GND.n1264 GND.n1263 0.125
R4932 GND.n651 GND.n650 0.125
R4933 GND.n1957 GND.n1956 0.125
R4934 GND.n1917 GND.n1916 0.125
R4935 GND.n1998 GND.n1997 0.125
R4936 GND.n1877 GND.n1876 0.125
R4937 GND.n2040 GND.n2039 0.125
R4938 GND.n1837 GND.n1836 0.125
R4939 GND.n2082 GND.n2081 0.125
R4940 GND.n1797 GND.n1796 0.125
R4941 GND.n2124 GND.n2123 0.125
R4942 GND.n1757 GND.n1756 0.125
R4943 GND.n2166 GND.n2165 0.125
R4944 GND.n1717 GND.n1716 0.125
R4945 GND.n2208 GND.n2207 0.125
R4946 GND.n1677 GND.n1676 0.125
R4947 GND.n2250 GND.n2249 0.125
R4948 GND.n1637 GND.n1636 0.125
R4949 GND.n2292 GND.n2291 0.125
R4950 GND.n1597 GND.n1596 0.125
R4951 GND.n2334 GND.n2333 0.125
R4952 GND.n1557 GND.n1556 0.125
R4953 GND.n2376 GND.n2375 0.125
R4954 GND.n1517 GND.n1516 0.125
R4955 GND.n2418 GND.n2417 0.125
R4956 GND.n1477 GND.n1476 0.125
R4957 GND.n2460 GND.n2459 0.125
R4958 GND.n1437 GND.n1436 0.125
R4959 GND.n2502 GND.n2501 0.125
R4960 GND.n1397 GND.n1396 0.125
R4961 GND.n2544 GND.n2543 0.125
R4962 GND.n1357 GND.n1356 0.125
R4963 GND.n2586 GND.n2585 0.125
R4964 GND.n1317 GND.n1316 0.125
R4965 GND.n3279 GND.n3278 0.125
R4966 GND.n3239 GND.n3238 0.125
R4967 GND.n3320 GND.n3319 0.125
R4968 GND.n3199 GND.n3198 0.125
R4969 GND.n3362 GND.n3361 0.125
R4970 GND.n3159 GND.n3158 0.125
R4971 GND.n3404 GND.n3403 0.125
R4972 GND.n3119 GND.n3118 0.125
R4973 GND.n3446 GND.n3445 0.125
R4974 GND.n3079 GND.n3078 0.125
R4975 GND.n3488 GND.n3487 0.125
R4976 GND.n3039 GND.n3038 0.125
R4977 GND.n3530 GND.n3529 0.125
R4978 GND.n2999 GND.n2998 0.125
R4979 GND.n3572 GND.n3571 0.125
R4980 GND.n2959 GND.n2958 0.125
R4981 GND.n3934 GND.n3933 0.125
R4982 GND.n3894 GND.n3893 0.125
R4983 GND.n3975 GND.n3974 0.125
R4984 GND.n3854 GND.n3853 0.125
R4985 GND.n4017 GND.n4016 0.125
R4986 GND.n3814 GND.n3813 0.125
R4987 GND.n4059 GND.n4058 0.125
R4988 GND.n3774 GND.n3773 0.125
R4989 GND.n4101 GND.n4100 0.125
R4990 GND.n3734 GND.n3733 0.125
R4991 GND.n4143 GND.n4142 0.125
R4992 GND.n3694 GND.n3693 0.125
R4993 GND.n4185 GND.n4184 0.125
R4994 GND.n3654 GND.n3653 0.125
R4995 GND.n4227 GND.n4226 0.125
R4996 GND.n3614 GND.n3613 0.125
R4997 GND.n4590 GND.n4589 0.125
R4998 GND.n4550 GND.n4549 0.125
R4999 GND.n4631 GND.n4630 0.125
R5000 GND.n4510 GND.n4509 0.125
R5001 GND.n4673 GND.n4672 0.125
R5002 GND.n4470 GND.n4469 0.125
R5003 GND.n4715 GND.n4714 0.125
R5004 GND.n4430 GND.n4429 0.125
R5005 GND.n4757 GND.n4756 0.125
R5006 GND.n4390 GND.n4389 0.125
R5007 GND.n4799 GND.n4798 0.125
R5008 GND.n4350 GND.n4349 0.125
R5009 GND.n4841 GND.n4840 0.125
R5010 GND.n4310 GND.n4309 0.125
R5011 GND.n4883 GND.n4882 0.125
R5012 GND.n4270 GND.n4269 0.125
R5013 GND.n4926 GND.n4925 0.125
R5014 GND.n2919 GND.n2918 0.125
R5015 GND.n4968 GND.n4967 0.125
R5016 GND.n2879 GND.n2878 0.125
R5017 GND.n5010 GND.n5009 0.125
R5018 GND.n2839 GND.n2838 0.125
R5019 GND.n5052 GND.n5051 0.125
R5020 GND.n2799 GND.n2798 0.125
R5021 GND.n5094 GND.n5093 0.125
R5022 GND.n2759 GND.n2758 0.125
R5023 GND.n5136 GND.n5135 0.125
R5024 GND.n2719 GND.n2718 0.125
R5025 GND.n5178 GND.n5177 0.125
R5026 GND.n2679 GND.n2678 0.125
R5027 GND.n5220 GND.n5219 0.125
R5028 GND.n2639 GND.n2638 0.125
R5029 GND.n5 GND.n4 0.103
R5030 GND.n97 GND.n96 0.103
R5031 GND.n271 GND.n270 0.103
R5032 GND.n609 GND.n608 0.103
R5033 GND.n1275 GND.n1274 0.103
R5034 GND.n2597 GND.n2596 0.103
R5035 GND.n71 GND.n70 0.053
R5036 GND.n203 GND.n202 0.053
R5037 GND.n163 GND.n162 0.053
R5038 GND.n172 GND.n171 0.053
R5039 GND.n244 GND.n243 0.053
R5040 GND.n123 GND.n122 0.053
R5041 GND.n132 GND.n131 0.053
R5042 GND.n457 GND.n456 0.053
R5043 GND.n417 GND.n416 0.053
R5044 GND.n426 GND.n425 0.053
R5045 GND.n498 GND.n497 0.053
R5046 GND.n377 GND.n376 0.053
R5047 GND.n386 GND.n385 0.053
R5048 GND.n540 GND.n539 0.053
R5049 GND.n337 GND.n336 0.053
R5050 GND.n346 GND.n345 0.053
R5051 GND.n582 GND.n581 0.053
R5052 GND.n297 GND.n296 0.053
R5053 GND.n306 GND.n305 0.053
R5054 GND.n955 GND.n954 0.053
R5055 GND.n915 GND.n914 0.053
R5056 GND.n924 GND.n923 0.053
R5057 GND.n996 GND.n995 0.053
R5058 GND.n875 GND.n874 0.053
R5059 GND.n884 GND.n883 0.053
R5060 GND.n1038 GND.n1037 0.053
R5061 GND.n835 GND.n834 0.053
R5062 GND.n844 GND.n843 0.053
R5063 GND.n1080 GND.n1079 0.053
R5064 GND.n795 GND.n794 0.053
R5065 GND.n804 GND.n803 0.053
R5066 GND.n1122 GND.n1121 0.053
R5067 GND.n755 GND.n754 0.053
R5068 GND.n764 GND.n763 0.053
R5069 GND.n1164 GND.n1163 0.053
R5070 GND.n715 GND.n714 0.053
R5071 GND.n724 GND.n723 0.053
R5072 GND.n1206 GND.n1205 0.053
R5073 GND.n675 GND.n674 0.053
R5074 GND.n684 GND.n683 0.053
R5075 GND.n1248 GND.n1247 0.053
R5076 GND.n635 GND.n634 0.053
R5077 GND.n644 GND.n643 0.053
R5078 GND.n1941 GND.n1940 0.053
R5079 GND.n1901 GND.n1900 0.053
R5080 GND.n1910 GND.n1909 0.053
R5081 GND.n1982 GND.n1981 0.053
R5082 GND.n1861 GND.n1860 0.053
R5083 GND.n1870 GND.n1869 0.053
R5084 GND.n2024 GND.n2023 0.053
R5085 GND.n1821 GND.n1820 0.053
R5086 GND.n1830 GND.n1829 0.053
R5087 GND.n2066 GND.n2065 0.053
R5088 GND.n1781 GND.n1780 0.053
R5089 GND.n1790 GND.n1789 0.053
R5090 GND.n2108 GND.n2107 0.053
R5091 GND.n1741 GND.n1740 0.053
R5092 GND.n1750 GND.n1749 0.053
R5093 GND.n2150 GND.n2149 0.053
R5094 GND.n1701 GND.n1700 0.053
R5095 GND.n1710 GND.n1709 0.053
R5096 GND.n2192 GND.n2191 0.053
R5097 GND.n1661 GND.n1660 0.053
R5098 GND.n1670 GND.n1669 0.053
R5099 GND.n2234 GND.n2233 0.053
R5100 GND.n1621 GND.n1620 0.053
R5101 GND.n1630 GND.n1629 0.053
R5102 GND.n2276 GND.n2275 0.053
R5103 GND.n1581 GND.n1580 0.053
R5104 GND.n1590 GND.n1589 0.053
R5105 GND.n2318 GND.n2317 0.053
R5106 GND.n1541 GND.n1540 0.053
R5107 GND.n1550 GND.n1549 0.053
R5108 GND.n2360 GND.n2359 0.053
R5109 GND.n1501 GND.n1500 0.053
R5110 GND.n1510 GND.n1509 0.053
R5111 GND.n2402 GND.n2401 0.053
R5112 GND.n1461 GND.n1460 0.053
R5113 GND.n1470 GND.n1469 0.053
R5114 GND.n2444 GND.n2443 0.053
R5115 GND.n1421 GND.n1420 0.053
R5116 GND.n1430 GND.n1429 0.053
R5117 GND.n2486 GND.n2485 0.053
R5118 GND.n1381 GND.n1380 0.053
R5119 GND.n1390 GND.n1389 0.053
R5120 GND.n2528 GND.n2527 0.053
R5121 GND.n1341 GND.n1340 0.053
R5122 GND.n1350 GND.n1349 0.053
R5123 GND.n2570 GND.n2569 0.053
R5124 GND.n1301 GND.n1300 0.053
R5125 GND.n1310 GND.n1309 0.053
R5126 GND.n3263 GND.n3262 0.053
R5127 GND.n3223 GND.n3222 0.053
R5128 GND.n3232 GND.n3231 0.053
R5129 GND.n3304 GND.n3303 0.053
R5130 GND.n3183 GND.n3182 0.053
R5131 GND.n3192 GND.n3191 0.053
R5132 GND.n3346 GND.n3345 0.053
R5133 GND.n3143 GND.n3142 0.053
R5134 GND.n3152 GND.n3151 0.053
R5135 GND.n3388 GND.n3387 0.053
R5136 GND.n3103 GND.n3102 0.053
R5137 GND.n3112 GND.n3111 0.053
R5138 GND.n3430 GND.n3429 0.053
R5139 GND.n3063 GND.n3062 0.053
R5140 GND.n3072 GND.n3071 0.053
R5141 GND.n3472 GND.n3471 0.053
R5142 GND.n3023 GND.n3022 0.053
R5143 GND.n3032 GND.n3031 0.053
R5144 GND.n3514 GND.n3513 0.053
R5145 GND.n2983 GND.n2982 0.053
R5146 GND.n2992 GND.n2991 0.053
R5147 GND.n3556 GND.n3555 0.053
R5148 GND.n2943 GND.n2942 0.053
R5149 GND.n2952 GND.n2951 0.053
R5150 GND.n3918 GND.n3917 0.053
R5151 GND.n3878 GND.n3877 0.053
R5152 GND.n3887 GND.n3886 0.053
R5153 GND.n3959 GND.n3958 0.053
R5154 GND.n3838 GND.n3837 0.053
R5155 GND.n3847 GND.n3846 0.053
R5156 GND.n4001 GND.n4000 0.053
R5157 GND.n3798 GND.n3797 0.053
R5158 GND.n3807 GND.n3806 0.053
R5159 GND.n4043 GND.n4042 0.053
R5160 GND.n3758 GND.n3757 0.053
R5161 GND.n3767 GND.n3766 0.053
R5162 GND.n4085 GND.n4084 0.053
R5163 GND.n3718 GND.n3717 0.053
R5164 GND.n3727 GND.n3726 0.053
R5165 GND.n4127 GND.n4126 0.053
R5166 GND.n3678 GND.n3677 0.053
R5167 GND.n3687 GND.n3686 0.053
R5168 GND.n4169 GND.n4168 0.053
R5169 GND.n3638 GND.n3637 0.053
R5170 GND.n3647 GND.n3646 0.053
R5171 GND.n4211 GND.n4210 0.053
R5172 GND.n3598 GND.n3597 0.053
R5173 GND.n3607 GND.n3606 0.053
R5174 GND.n4574 GND.n4573 0.053
R5175 GND.n4534 GND.n4533 0.053
R5176 GND.n4543 GND.n4542 0.053
R5177 GND.n4615 GND.n4614 0.053
R5178 GND.n4494 GND.n4493 0.053
R5179 GND.n4503 GND.n4502 0.053
R5180 GND.n4657 GND.n4656 0.053
R5181 GND.n4454 GND.n4453 0.053
R5182 GND.n4463 GND.n4462 0.053
R5183 GND.n4699 GND.n4698 0.053
R5184 GND.n4414 GND.n4413 0.053
R5185 GND.n4423 GND.n4422 0.053
R5186 GND.n4741 GND.n4740 0.053
R5187 GND.n4374 GND.n4373 0.053
R5188 GND.n4383 GND.n4382 0.053
R5189 GND.n4783 GND.n4782 0.053
R5190 GND.n4334 GND.n4333 0.053
R5191 GND.n4343 GND.n4342 0.053
R5192 GND.n4825 GND.n4824 0.053
R5193 GND.n4294 GND.n4293 0.053
R5194 GND.n4303 GND.n4302 0.053
R5195 GND.n4867 GND.n4866 0.053
R5196 GND.n4254 GND.n4253 0.053
R5197 GND.n4263 GND.n4262 0.053
R5198 GND.n4910 GND.n4909 0.053
R5199 GND.n2903 GND.n2902 0.053
R5200 GND.n2912 GND.n2911 0.053
R5201 GND.n4952 GND.n4951 0.053
R5202 GND.n2863 GND.n2862 0.053
R5203 GND.n2872 GND.n2871 0.053
R5204 GND.n4994 GND.n4993 0.053
R5205 GND.n2823 GND.n2822 0.053
R5206 GND.n2832 GND.n2831 0.053
R5207 GND.n5036 GND.n5035 0.053
R5208 GND.n2783 GND.n2782 0.053
R5209 GND.n2792 GND.n2791 0.053
R5210 GND.n5078 GND.n5077 0.053
R5211 GND.n2743 GND.n2742 0.053
R5212 GND.n2752 GND.n2751 0.053
R5213 GND.n5120 GND.n5119 0.053
R5214 GND.n2703 GND.n2702 0.053
R5215 GND.n2712 GND.n2711 0.053
R5216 GND.n5162 GND.n5161 0.053
R5217 GND.n2663 GND.n2662 0.053
R5218 GND.n2672 GND.n2671 0.053
R5219 GND.n5204 GND.n5203 0.053
R5220 GND.n2623 GND.n2622 0.053
R5221 GND.n2632 GND.n2631 0.053
R5222 GND.n6 GND.n5 0.049
R5223 GND.n98 GND.n97 0.049
R5224 GND.n272 GND.n271 0.049
R5225 GND.n610 GND.n609 0.049
R5226 GND.n1276 GND.n1275 0.049
R5227 GND.n2598 GND.n2597 0.049
R5228 GND.n65 GND.n63 0.034
R5229 GND.n86 GND.n84 0.034
R5230 GND.n17 GND.n15 0.034
R5231 GND.n39 GND.n37 0.034
R5232 GND.n197 GND.n195 0.034
R5233 GND.n218 GND.n216 0.034
R5234 GND.n157 GND.n155 0.034
R5235 GND.n178 GND.n176 0.034
R5236 GND.n238 GND.n236 0.034
R5237 GND.n259 GND.n257 0.034
R5238 GND.n117 GND.n115 0.034
R5239 GND.n138 GND.n136 0.034
R5240 GND.n451 GND.n449 0.034
R5241 GND.n472 GND.n470 0.034
R5242 GND.n411 GND.n409 0.034
R5243 GND.n432 GND.n430 0.034
R5244 GND.n492 GND.n490 0.034
R5245 GND.n513 GND.n511 0.034
R5246 GND.n371 GND.n369 0.034
R5247 GND.n392 GND.n390 0.034
R5248 GND.n534 GND.n532 0.034
R5249 GND.n555 GND.n553 0.034
R5250 GND.n331 GND.n329 0.034
R5251 GND.n352 GND.n350 0.034
R5252 GND.n576 GND.n574 0.034
R5253 GND.n597 GND.n595 0.034
R5254 GND.n291 GND.n289 0.034
R5255 GND.n312 GND.n310 0.034
R5256 GND.n949 GND.n947 0.034
R5257 GND.n970 GND.n968 0.034
R5258 GND.n909 GND.n907 0.034
R5259 GND.n930 GND.n928 0.034
R5260 GND.n990 GND.n988 0.034
R5261 GND.n1011 GND.n1009 0.034
R5262 GND.n869 GND.n867 0.034
R5263 GND.n890 GND.n888 0.034
R5264 GND.n1032 GND.n1030 0.034
R5265 GND.n1053 GND.n1051 0.034
R5266 GND.n829 GND.n827 0.034
R5267 GND.n850 GND.n848 0.034
R5268 GND.n1074 GND.n1072 0.034
R5269 GND.n1095 GND.n1093 0.034
R5270 GND.n789 GND.n787 0.034
R5271 GND.n810 GND.n808 0.034
R5272 GND.n1116 GND.n1114 0.034
R5273 GND.n1137 GND.n1135 0.034
R5274 GND.n749 GND.n747 0.034
R5275 GND.n770 GND.n768 0.034
R5276 GND.n1158 GND.n1156 0.034
R5277 GND.n1179 GND.n1177 0.034
R5278 GND.n709 GND.n707 0.034
R5279 GND.n730 GND.n728 0.034
R5280 GND.n1200 GND.n1198 0.034
R5281 GND.n1221 GND.n1219 0.034
R5282 GND.n669 GND.n667 0.034
R5283 GND.n690 GND.n688 0.034
R5284 GND.n1242 GND.n1240 0.034
R5285 GND.n1263 GND.n1261 0.034
R5286 GND.n629 GND.n627 0.034
R5287 GND.n650 GND.n648 0.034
R5288 GND.n1935 GND.n1933 0.034
R5289 GND.n1956 GND.n1954 0.034
R5290 GND.n1895 GND.n1893 0.034
R5291 GND.n1916 GND.n1914 0.034
R5292 GND.n1976 GND.n1974 0.034
R5293 GND.n1997 GND.n1995 0.034
R5294 GND.n1855 GND.n1853 0.034
R5295 GND.n1876 GND.n1874 0.034
R5296 GND.n2018 GND.n2016 0.034
R5297 GND.n2039 GND.n2037 0.034
R5298 GND.n1815 GND.n1813 0.034
R5299 GND.n1836 GND.n1834 0.034
R5300 GND.n2060 GND.n2058 0.034
R5301 GND.n2081 GND.n2079 0.034
R5302 GND.n1775 GND.n1773 0.034
R5303 GND.n1796 GND.n1794 0.034
R5304 GND.n2102 GND.n2100 0.034
R5305 GND.n2123 GND.n2121 0.034
R5306 GND.n1735 GND.n1733 0.034
R5307 GND.n1756 GND.n1754 0.034
R5308 GND.n2144 GND.n2142 0.034
R5309 GND.n2165 GND.n2163 0.034
R5310 GND.n1695 GND.n1693 0.034
R5311 GND.n1716 GND.n1714 0.034
R5312 GND.n2186 GND.n2184 0.034
R5313 GND.n2207 GND.n2205 0.034
R5314 GND.n1655 GND.n1653 0.034
R5315 GND.n1676 GND.n1674 0.034
R5316 GND.n2228 GND.n2226 0.034
R5317 GND.n2249 GND.n2247 0.034
R5318 GND.n1615 GND.n1613 0.034
R5319 GND.n1636 GND.n1634 0.034
R5320 GND.n2270 GND.n2268 0.034
R5321 GND.n2291 GND.n2289 0.034
R5322 GND.n1575 GND.n1573 0.034
R5323 GND.n1596 GND.n1594 0.034
R5324 GND.n2312 GND.n2310 0.034
R5325 GND.n2333 GND.n2331 0.034
R5326 GND.n1535 GND.n1533 0.034
R5327 GND.n1556 GND.n1554 0.034
R5328 GND.n2354 GND.n2352 0.034
R5329 GND.n2375 GND.n2373 0.034
R5330 GND.n1495 GND.n1493 0.034
R5331 GND.n1516 GND.n1514 0.034
R5332 GND.n2396 GND.n2394 0.034
R5333 GND.n2417 GND.n2415 0.034
R5334 GND.n1455 GND.n1453 0.034
R5335 GND.n1476 GND.n1474 0.034
R5336 GND.n2438 GND.n2436 0.034
R5337 GND.n2459 GND.n2457 0.034
R5338 GND.n1415 GND.n1413 0.034
R5339 GND.n1436 GND.n1434 0.034
R5340 GND.n2480 GND.n2478 0.034
R5341 GND.n2501 GND.n2499 0.034
R5342 GND.n1375 GND.n1373 0.034
R5343 GND.n1396 GND.n1394 0.034
R5344 GND.n2522 GND.n2520 0.034
R5345 GND.n2543 GND.n2541 0.034
R5346 GND.n1335 GND.n1333 0.034
R5347 GND.n1356 GND.n1354 0.034
R5348 GND.n2564 GND.n2562 0.034
R5349 GND.n2585 GND.n2583 0.034
R5350 GND.n1295 GND.n1293 0.034
R5351 GND.n1316 GND.n1314 0.034
R5352 GND.n3257 GND.n3255 0.034
R5353 GND.n3278 GND.n3276 0.034
R5354 GND.n3217 GND.n3215 0.034
R5355 GND.n3238 GND.n3236 0.034
R5356 GND.n3298 GND.n3296 0.034
R5357 GND.n3319 GND.n3317 0.034
R5358 GND.n3177 GND.n3175 0.034
R5359 GND.n3198 GND.n3196 0.034
R5360 GND.n3340 GND.n3338 0.034
R5361 GND.n3361 GND.n3359 0.034
R5362 GND.n3137 GND.n3135 0.034
R5363 GND.n3158 GND.n3156 0.034
R5364 GND.n3382 GND.n3380 0.034
R5365 GND.n3403 GND.n3401 0.034
R5366 GND.n3097 GND.n3095 0.034
R5367 GND.n3118 GND.n3116 0.034
R5368 GND.n3424 GND.n3422 0.034
R5369 GND.n3445 GND.n3443 0.034
R5370 GND.n3057 GND.n3055 0.034
R5371 GND.n3078 GND.n3076 0.034
R5372 GND.n3466 GND.n3464 0.034
R5373 GND.n3487 GND.n3485 0.034
R5374 GND.n3017 GND.n3015 0.034
R5375 GND.n3038 GND.n3036 0.034
R5376 GND.n3508 GND.n3506 0.034
R5377 GND.n3529 GND.n3527 0.034
R5378 GND.n2977 GND.n2975 0.034
R5379 GND.n2998 GND.n2996 0.034
R5380 GND.n3550 GND.n3548 0.034
R5381 GND.n3571 GND.n3569 0.034
R5382 GND.n2937 GND.n2935 0.034
R5383 GND.n2958 GND.n2956 0.034
R5384 GND.n3912 GND.n3910 0.034
R5385 GND.n3933 GND.n3931 0.034
R5386 GND.n3872 GND.n3870 0.034
R5387 GND.n3893 GND.n3891 0.034
R5388 GND.n3953 GND.n3951 0.034
R5389 GND.n3974 GND.n3972 0.034
R5390 GND.n3832 GND.n3830 0.034
R5391 GND.n3853 GND.n3851 0.034
R5392 GND.n3995 GND.n3993 0.034
R5393 GND.n4016 GND.n4014 0.034
R5394 GND.n3792 GND.n3790 0.034
R5395 GND.n3813 GND.n3811 0.034
R5396 GND.n4037 GND.n4035 0.034
R5397 GND.n4058 GND.n4056 0.034
R5398 GND.n3752 GND.n3750 0.034
R5399 GND.n3773 GND.n3771 0.034
R5400 GND.n4079 GND.n4077 0.034
R5401 GND.n4100 GND.n4098 0.034
R5402 GND.n3712 GND.n3710 0.034
R5403 GND.n3733 GND.n3731 0.034
R5404 GND.n4121 GND.n4119 0.034
R5405 GND.n4142 GND.n4140 0.034
R5406 GND.n3672 GND.n3670 0.034
R5407 GND.n3693 GND.n3691 0.034
R5408 GND.n4163 GND.n4161 0.034
R5409 GND.n4184 GND.n4182 0.034
R5410 GND.n3632 GND.n3630 0.034
R5411 GND.n3653 GND.n3651 0.034
R5412 GND.n4205 GND.n4203 0.034
R5413 GND.n4226 GND.n4224 0.034
R5414 GND.n3592 GND.n3590 0.034
R5415 GND.n3613 GND.n3611 0.034
R5416 GND.n4568 GND.n4566 0.034
R5417 GND.n4589 GND.n4587 0.034
R5418 GND.n4528 GND.n4526 0.034
R5419 GND.n4549 GND.n4547 0.034
R5420 GND.n4609 GND.n4607 0.034
R5421 GND.n4630 GND.n4628 0.034
R5422 GND.n4488 GND.n4486 0.034
R5423 GND.n4509 GND.n4507 0.034
R5424 GND.n4651 GND.n4649 0.034
R5425 GND.n4672 GND.n4670 0.034
R5426 GND.n4448 GND.n4446 0.034
R5427 GND.n4469 GND.n4467 0.034
R5428 GND.n4693 GND.n4691 0.034
R5429 GND.n4714 GND.n4712 0.034
R5430 GND.n4408 GND.n4406 0.034
R5431 GND.n4429 GND.n4427 0.034
R5432 GND.n4735 GND.n4733 0.034
R5433 GND.n4756 GND.n4754 0.034
R5434 GND.n4368 GND.n4366 0.034
R5435 GND.n4389 GND.n4387 0.034
R5436 GND.n4777 GND.n4775 0.034
R5437 GND.n4798 GND.n4796 0.034
R5438 GND.n4328 GND.n4326 0.034
R5439 GND.n4349 GND.n4347 0.034
R5440 GND.n4819 GND.n4817 0.034
R5441 GND.n4840 GND.n4838 0.034
R5442 GND.n4288 GND.n4286 0.034
R5443 GND.n4309 GND.n4307 0.034
R5444 GND.n4861 GND.n4859 0.034
R5445 GND.n4882 GND.n4880 0.034
R5446 GND.n4248 GND.n4246 0.034
R5447 GND.n4269 GND.n4267 0.034
R5448 GND.n4904 GND.n4902 0.034
R5449 GND.n4925 GND.n4923 0.034
R5450 GND.n2897 GND.n2895 0.034
R5451 GND.n2918 GND.n2916 0.034
R5452 GND.n4946 GND.n4944 0.034
R5453 GND.n4967 GND.n4965 0.034
R5454 GND.n2857 GND.n2855 0.034
R5455 GND.n2878 GND.n2876 0.034
R5456 GND.n4988 GND.n4986 0.034
R5457 GND.n5009 GND.n5007 0.034
R5458 GND.n2817 GND.n2815 0.034
R5459 GND.n2838 GND.n2836 0.034
R5460 GND.n5030 GND.n5028 0.034
R5461 GND.n5051 GND.n5049 0.034
R5462 GND.n2777 GND.n2775 0.034
R5463 GND.n2798 GND.n2796 0.034
R5464 GND.n5072 GND.n5070 0.034
R5465 GND.n5093 GND.n5091 0.034
R5466 GND.n2737 GND.n2735 0.034
R5467 GND.n2758 GND.n2756 0.034
R5468 GND.n5114 GND.n5112 0.034
R5469 GND.n5135 GND.n5133 0.034
R5470 GND.n2697 GND.n2695 0.034
R5471 GND.n2718 GND.n2716 0.034
R5472 GND.n5156 GND.n5154 0.034
R5473 GND.n5177 GND.n5175 0.034
R5474 GND.n2657 GND.n2655 0.034
R5475 GND.n2678 GND.n2676 0.034
R5476 GND.n5198 GND.n5196 0.034
R5477 GND.n5219 GND.n5217 0.034
R5478 GND.n2617 GND.n2615 0.034
R5479 GND.n2638 GND.n2636 0.034
R5480 GND.n91 GND.n90 0.011
R5481 GND.n265 GND.n264 0.011
R5482 GND.n603 GND.n602 0.011
R5483 GND.n1269 GND.n1268 0.011
R5484 GND.n2591 GND.n2590 0.011
R5485 GND.n5225 GND.n5224 0.011
R5486 GND.n91 GND.n7 0.011
R5487 GND.n265 GND.n99 0.011
R5488 GND.n603 GND.n273 0.011
R5489 GND.n1269 GND.n611 0.011
R5490 GND.n2591 GND.n1277 0.011
R5491 GND.n5225 GND.n2599 0.011
R5492 GND.n7 GND.n6 0.003
R5493 GND.n99 GND.n98 0.003
R5494 GND.n273 GND.n272 0.003
R5495 GND.n611 GND.n610 0.003
R5496 GND.n1277 GND.n1276 0.003
R5497 GND.n2599 GND.n2598 0.003
R5498 GND.n73 GND.n65 0.002
R5499 GND.n84 GND.n82 0.002
R5500 GND.n26 GND.n17 0.002
R5501 GND.n37 GND.n35 0.002
R5502 GND.n205 GND.n197 0.002
R5503 GND.n216 GND.n214 0.002
R5504 GND.n165 GND.n157 0.002
R5505 GND.n176 GND.n174 0.002
R5506 GND.n246 GND.n238 0.002
R5507 GND.n257 GND.n255 0.002
R5508 GND.n125 GND.n117 0.002
R5509 GND.n136 GND.n134 0.002
R5510 GND.n459 GND.n451 0.002
R5511 GND.n470 GND.n468 0.002
R5512 GND.n419 GND.n411 0.002
R5513 GND.n430 GND.n428 0.002
R5514 GND.n500 GND.n492 0.002
R5515 GND.n511 GND.n509 0.002
R5516 GND.n379 GND.n371 0.002
R5517 GND.n390 GND.n388 0.002
R5518 GND.n542 GND.n534 0.002
R5519 GND.n553 GND.n551 0.002
R5520 GND.n339 GND.n331 0.002
R5521 GND.n350 GND.n348 0.002
R5522 GND.n584 GND.n576 0.002
R5523 GND.n595 GND.n593 0.002
R5524 GND.n299 GND.n291 0.002
R5525 GND.n310 GND.n308 0.002
R5526 GND.n957 GND.n949 0.002
R5527 GND.n968 GND.n966 0.002
R5528 GND.n917 GND.n909 0.002
R5529 GND.n928 GND.n926 0.002
R5530 GND.n998 GND.n990 0.002
R5531 GND.n1009 GND.n1007 0.002
R5532 GND.n877 GND.n869 0.002
R5533 GND.n888 GND.n886 0.002
R5534 GND.n1040 GND.n1032 0.002
R5535 GND.n1051 GND.n1049 0.002
R5536 GND.n837 GND.n829 0.002
R5537 GND.n848 GND.n846 0.002
R5538 GND.n1082 GND.n1074 0.002
R5539 GND.n1093 GND.n1091 0.002
R5540 GND.n797 GND.n789 0.002
R5541 GND.n808 GND.n806 0.002
R5542 GND.n1124 GND.n1116 0.002
R5543 GND.n1135 GND.n1133 0.002
R5544 GND.n757 GND.n749 0.002
R5545 GND.n768 GND.n766 0.002
R5546 GND.n1166 GND.n1158 0.002
R5547 GND.n1177 GND.n1175 0.002
R5548 GND.n717 GND.n709 0.002
R5549 GND.n728 GND.n726 0.002
R5550 GND.n1208 GND.n1200 0.002
R5551 GND.n1219 GND.n1217 0.002
R5552 GND.n677 GND.n669 0.002
R5553 GND.n688 GND.n686 0.002
R5554 GND.n1250 GND.n1242 0.002
R5555 GND.n1261 GND.n1259 0.002
R5556 GND.n637 GND.n629 0.002
R5557 GND.n648 GND.n646 0.002
R5558 GND.n1943 GND.n1935 0.002
R5559 GND.n1954 GND.n1952 0.002
R5560 GND.n1903 GND.n1895 0.002
R5561 GND.n1914 GND.n1912 0.002
R5562 GND.n1984 GND.n1976 0.002
R5563 GND.n1995 GND.n1993 0.002
R5564 GND.n1863 GND.n1855 0.002
R5565 GND.n1874 GND.n1872 0.002
R5566 GND.n2026 GND.n2018 0.002
R5567 GND.n2037 GND.n2035 0.002
R5568 GND.n1823 GND.n1815 0.002
R5569 GND.n1834 GND.n1832 0.002
R5570 GND.n2068 GND.n2060 0.002
R5571 GND.n2079 GND.n2077 0.002
R5572 GND.n1783 GND.n1775 0.002
R5573 GND.n1794 GND.n1792 0.002
R5574 GND.n2110 GND.n2102 0.002
R5575 GND.n2121 GND.n2119 0.002
R5576 GND.n1743 GND.n1735 0.002
R5577 GND.n1754 GND.n1752 0.002
R5578 GND.n2152 GND.n2144 0.002
R5579 GND.n2163 GND.n2161 0.002
R5580 GND.n1703 GND.n1695 0.002
R5581 GND.n1714 GND.n1712 0.002
R5582 GND.n2194 GND.n2186 0.002
R5583 GND.n2205 GND.n2203 0.002
R5584 GND.n1663 GND.n1655 0.002
R5585 GND.n1674 GND.n1672 0.002
R5586 GND.n2236 GND.n2228 0.002
R5587 GND.n2247 GND.n2245 0.002
R5588 GND.n1623 GND.n1615 0.002
R5589 GND.n1634 GND.n1632 0.002
R5590 GND.n2278 GND.n2270 0.002
R5591 GND.n2289 GND.n2287 0.002
R5592 GND.n1583 GND.n1575 0.002
R5593 GND.n1594 GND.n1592 0.002
R5594 GND.n2320 GND.n2312 0.002
R5595 GND.n2331 GND.n2329 0.002
R5596 GND.n1543 GND.n1535 0.002
R5597 GND.n1554 GND.n1552 0.002
R5598 GND.n2362 GND.n2354 0.002
R5599 GND.n2373 GND.n2371 0.002
R5600 GND.n1503 GND.n1495 0.002
R5601 GND.n1514 GND.n1512 0.002
R5602 GND.n2404 GND.n2396 0.002
R5603 GND.n2415 GND.n2413 0.002
R5604 GND.n1463 GND.n1455 0.002
R5605 GND.n1474 GND.n1472 0.002
R5606 GND.n2446 GND.n2438 0.002
R5607 GND.n2457 GND.n2455 0.002
R5608 GND.n1423 GND.n1415 0.002
R5609 GND.n1434 GND.n1432 0.002
R5610 GND.n2488 GND.n2480 0.002
R5611 GND.n2499 GND.n2497 0.002
R5612 GND.n1383 GND.n1375 0.002
R5613 GND.n1394 GND.n1392 0.002
R5614 GND.n2530 GND.n2522 0.002
R5615 GND.n2541 GND.n2539 0.002
R5616 GND.n1343 GND.n1335 0.002
R5617 GND.n1354 GND.n1352 0.002
R5618 GND.n2572 GND.n2564 0.002
R5619 GND.n2583 GND.n2581 0.002
R5620 GND.n1303 GND.n1295 0.002
R5621 GND.n1314 GND.n1312 0.002
R5622 GND.n3265 GND.n3257 0.002
R5623 GND.n3276 GND.n3274 0.002
R5624 GND.n3225 GND.n3217 0.002
R5625 GND.n3236 GND.n3234 0.002
R5626 GND.n3306 GND.n3298 0.002
R5627 GND.n3317 GND.n3315 0.002
R5628 GND.n3185 GND.n3177 0.002
R5629 GND.n3196 GND.n3194 0.002
R5630 GND.n3348 GND.n3340 0.002
R5631 GND.n3359 GND.n3357 0.002
R5632 GND.n3145 GND.n3137 0.002
R5633 GND.n3156 GND.n3154 0.002
R5634 GND.n3390 GND.n3382 0.002
R5635 GND.n3401 GND.n3399 0.002
R5636 GND.n3105 GND.n3097 0.002
R5637 GND.n3116 GND.n3114 0.002
R5638 GND.n3432 GND.n3424 0.002
R5639 GND.n3443 GND.n3441 0.002
R5640 GND.n3065 GND.n3057 0.002
R5641 GND.n3076 GND.n3074 0.002
R5642 GND.n3474 GND.n3466 0.002
R5643 GND.n3485 GND.n3483 0.002
R5644 GND.n3025 GND.n3017 0.002
R5645 GND.n3036 GND.n3034 0.002
R5646 GND.n3516 GND.n3508 0.002
R5647 GND.n3527 GND.n3525 0.002
R5648 GND.n2985 GND.n2977 0.002
R5649 GND.n2996 GND.n2994 0.002
R5650 GND.n3558 GND.n3550 0.002
R5651 GND.n3569 GND.n3567 0.002
R5652 GND.n2945 GND.n2937 0.002
R5653 GND.n2956 GND.n2954 0.002
R5654 GND.n3920 GND.n3912 0.002
R5655 GND.n3931 GND.n3929 0.002
R5656 GND.n3880 GND.n3872 0.002
R5657 GND.n3891 GND.n3889 0.002
R5658 GND.n3961 GND.n3953 0.002
R5659 GND.n3972 GND.n3970 0.002
R5660 GND.n3840 GND.n3832 0.002
R5661 GND.n3851 GND.n3849 0.002
R5662 GND.n4003 GND.n3995 0.002
R5663 GND.n4014 GND.n4012 0.002
R5664 GND.n3800 GND.n3792 0.002
R5665 GND.n3811 GND.n3809 0.002
R5666 GND.n4045 GND.n4037 0.002
R5667 GND.n4056 GND.n4054 0.002
R5668 GND.n3760 GND.n3752 0.002
R5669 GND.n3771 GND.n3769 0.002
R5670 GND.n4087 GND.n4079 0.002
R5671 GND.n4098 GND.n4096 0.002
R5672 GND.n3720 GND.n3712 0.002
R5673 GND.n3731 GND.n3729 0.002
R5674 GND.n4129 GND.n4121 0.002
R5675 GND.n4140 GND.n4138 0.002
R5676 GND.n3680 GND.n3672 0.002
R5677 GND.n3691 GND.n3689 0.002
R5678 GND.n4171 GND.n4163 0.002
R5679 GND.n4182 GND.n4180 0.002
R5680 GND.n3640 GND.n3632 0.002
R5681 GND.n3651 GND.n3649 0.002
R5682 GND.n4213 GND.n4205 0.002
R5683 GND.n4224 GND.n4222 0.002
R5684 GND.n3600 GND.n3592 0.002
R5685 GND.n3611 GND.n3609 0.002
R5686 GND.n4576 GND.n4568 0.002
R5687 GND.n4587 GND.n4585 0.002
R5688 GND.n4536 GND.n4528 0.002
R5689 GND.n4547 GND.n4545 0.002
R5690 GND.n4617 GND.n4609 0.002
R5691 GND.n4628 GND.n4626 0.002
R5692 GND.n4496 GND.n4488 0.002
R5693 GND.n4507 GND.n4505 0.002
R5694 GND.n4659 GND.n4651 0.002
R5695 GND.n4670 GND.n4668 0.002
R5696 GND.n4456 GND.n4448 0.002
R5697 GND.n4467 GND.n4465 0.002
R5698 GND.n4701 GND.n4693 0.002
R5699 GND.n4712 GND.n4710 0.002
R5700 GND.n4416 GND.n4408 0.002
R5701 GND.n4427 GND.n4425 0.002
R5702 GND.n4743 GND.n4735 0.002
R5703 GND.n4754 GND.n4752 0.002
R5704 GND.n4376 GND.n4368 0.002
R5705 GND.n4387 GND.n4385 0.002
R5706 GND.n4785 GND.n4777 0.002
R5707 GND.n4796 GND.n4794 0.002
R5708 GND.n4336 GND.n4328 0.002
R5709 GND.n4347 GND.n4345 0.002
R5710 GND.n4827 GND.n4819 0.002
R5711 GND.n4838 GND.n4836 0.002
R5712 GND.n4296 GND.n4288 0.002
R5713 GND.n4307 GND.n4305 0.002
R5714 GND.n4869 GND.n4861 0.002
R5715 GND.n4880 GND.n4878 0.002
R5716 GND.n4256 GND.n4248 0.002
R5717 GND.n4267 GND.n4265 0.002
R5718 GND.n4912 GND.n4904 0.002
R5719 GND.n4923 GND.n4921 0.002
R5720 GND.n2905 GND.n2897 0.002
R5721 GND.n2916 GND.n2914 0.002
R5722 GND.n4954 GND.n4946 0.002
R5723 GND.n4965 GND.n4963 0.002
R5724 GND.n2865 GND.n2857 0.002
R5725 GND.n2876 GND.n2874 0.002
R5726 GND.n4996 GND.n4988 0.002
R5727 GND.n5007 GND.n5005 0.002
R5728 GND.n2825 GND.n2817 0.002
R5729 GND.n2836 GND.n2834 0.002
R5730 GND.n5038 GND.n5030 0.002
R5731 GND.n5049 GND.n5047 0.002
R5732 GND.n2785 GND.n2777 0.002
R5733 GND.n2796 GND.n2794 0.002
R5734 GND.n5080 GND.n5072 0.002
R5735 GND.n5091 GND.n5089 0.002
R5736 GND.n2745 GND.n2737 0.002
R5737 GND.n2756 GND.n2754 0.002
R5738 GND.n5122 GND.n5114 0.002
R5739 GND.n5133 GND.n5131 0.002
R5740 GND.n2705 GND.n2697 0.002
R5741 GND.n2716 GND.n2714 0.002
R5742 GND.n5164 GND.n5156 0.002
R5743 GND.n5175 GND.n5173 0.002
R5744 GND.n2665 GND.n2657 0.002
R5745 GND.n2676 GND.n2674 0.002
R5746 GND.n5206 GND.n5198 0.002
R5747 GND.n5217 GND.n5215 0.002
R5748 GND.n2625 GND.n2617 0.002
R5749 GND.n2636 GND.n2634 0.002
R5750 a_1416_4186.n10 a_1416_4186.t0 10.181
R5751 a_1416_4186.n10 a_1416_4186.t1 10.181
R5752 a_1416_4186.t2 a_1416_4186.n18 9.68
R5753 a_1416_4186.n1 a_1416_4186.n0 9.302
R5754 a_1416_4186.n7 a_1416_4186.n6 9.3
R5755 a_1416_4186.n5 a_1416_4186.n4 9.3
R5756 a_1416_4186.n9 a_1416_4186.n8 9
R5757 a_1416_4186.n13 a_1416_4186.n12 7.729
R5758 a_1416_4186.n13 a_1416_4186.n10 6.296
R5759 a_1416_4186.n16 a_1416_4186.n1 4.508
R5760 a_1416_4186.n15 a_1416_4186.n14 4.501
R5761 a_1416_4186.n15 a_1416_4186.n9 4.501
R5762 a_1416_4186.n16 a_1416_4186.n3 4.494
R5763 a_1416_4186.n18 a_1416_4186.t3 1.259
R5764 a_1416_4186.n12 a_1416_4186.n11 0.536
R5765 a_1416_4186.n18 a_1416_4186.n17 0.415
R5766 a_1416_4186.n14 a_1416_4186.n13 0.151
R5767 a_1416_4186.n7 a_1416_4186.n5 0.028
R5768 a_1416_4186.n3 a_1416_4186.n2 0.025
R5769 a_1416_4186.n17 a_1416_4186.n16 0.021
R5770 a_1416_4186.n9 a_1416_4186.n7 0.012
R5771 a_1416_4186.n16 a_1416_4186.n15 0.006
R5772 OUT_N.n58 OUT_N.n23 3.008
R5773 OUT_N.n59 OUT_N.n17 3.008
R5774 OUT_N.n60 OUT_N.n11 3.008
R5775 OUT_N.n61 OUT_N.n5 3.008
R5776 OUT_N.n55 OUT_N.n54 2.189
R5777 OUT_N.n56 OUT_N.n37 2.147
R5778 OUT_N.n57 OUT_N.n30 2.147
R5779 OUT_N.n61 OUT_N.n60 1.762
R5780 OUT_N.n60 OUT_N.n59 1.762
R5781 OUT_N.n59 OUT_N.n58 1.762
R5782 OUT_N.n58 OUT_N.n57 1.762
R5783 OUT_N.n57 OUT_N.n56 1.762
R5784 OUT_N.n56 OUT_N.n55 1.762
R5785 OUT_N.n55 OUT_N.n45 1.287
R5786 OUT_N.n46 OUT_N.t13 0.965
R5787 OUT_N.n38 OUT_N.t5 0.965
R5788 OUT_N.n31 OUT_N.t31 0.965
R5789 OUT_N.n24 OUT_N.t2 0.965
R5790 OUT_N.n18 OUT_N.t41 0.965
R5791 OUT_N.n12 OUT_N.t27 0.965
R5792 OUT_N.n6 OUT_N.t1 0.965
R5793 OUT_N.n0 OUT_N.t37 0.965
R5794 OUT_N.n47 OUT_N.n46 0.813
R5795 OUT_N.n48 OUT_N.n47 0.813
R5796 OUT_N.n49 OUT_N.n48 0.813
R5797 OUT_N.n50 OUT_N.n49 0.813
R5798 OUT_N.n51 OUT_N.n50 0.813
R5799 OUT_N.n52 OUT_N.n51 0.813
R5800 OUT_N.n53 OUT_N.n52 0.813
R5801 OUT_N.n54 OUT_N.n53 0.813
R5802 OUT_N.n39 OUT_N.n38 0.813
R5803 OUT_N.n40 OUT_N.n39 0.813
R5804 OUT_N.n41 OUT_N.n40 0.813
R5805 OUT_N.n42 OUT_N.n41 0.813
R5806 OUT_N.n43 OUT_N.n42 0.813
R5807 OUT_N.n44 OUT_N.n43 0.813
R5808 OUT_N.n45 OUT_N.n44 0.813
R5809 OUT_N.n32 OUT_N.n31 0.813
R5810 OUT_N.n33 OUT_N.n32 0.813
R5811 OUT_N.n34 OUT_N.n33 0.813
R5812 OUT_N.n35 OUT_N.n34 0.813
R5813 OUT_N.n36 OUT_N.n35 0.813
R5814 OUT_N.n37 OUT_N.n36 0.813
R5815 OUT_N.n25 OUT_N.n24 0.813
R5816 OUT_N.n26 OUT_N.n25 0.813
R5817 OUT_N.n27 OUT_N.n26 0.813
R5818 OUT_N.n28 OUT_N.n27 0.813
R5819 OUT_N.n29 OUT_N.n28 0.813
R5820 OUT_N.n30 OUT_N.n29 0.813
R5821 OUT_N.n19 OUT_N.n18 0.813
R5822 OUT_N.n20 OUT_N.n19 0.813
R5823 OUT_N.n21 OUT_N.n20 0.813
R5824 OUT_N.n22 OUT_N.n21 0.813
R5825 OUT_N.n23 OUT_N.n22 0.813
R5826 OUT_N.n13 OUT_N.n12 0.813
R5827 OUT_N.n14 OUT_N.n13 0.813
R5828 OUT_N.n15 OUT_N.n14 0.813
R5829 OUT_N.n16 OUT_N.n15 0.813
R5830 OUT_N.n17 OUT_N.n16 0.813
R5831 OUT_N.n7 OUT_N.n6 0.813
R5832 OUT_N.n8 OUT_N.n7 0.813
R5833 OUT_N.n9 OUT_N.n8 0.813
R5834 OUT_N.n10 OUT_N.n9 0.813
R5835 OUT_N.n11 OUT_N.n10 0.813
R5836 OUT_N.n1 OUT_N.n0 0.813
R5837 OUT_N.n2 OUT_N.n1 0.813
R5838 OUT_N.n3 OUT_N.n2 0.813
R5839 OUT_N.n4 OUT_N.n3 0.813
R5840 OUT_N.n5 OUT_N.n4 0.813
R5841 OUT_N OUT_N.n61 0.263
R5842 OUT_N.n46 OUT_N.t18 0.152
R5843 OUT_N.n47 OUT_N.t47 0.152
R5844 OUT_N.n48 OUT_N.t21 0.152
R5845 OUT_N.n49 OUT_N.t19 0.152
R5846 OUT_N.n50 OUT_N.t48 0.152
R5847 OUT_N.n51 OUT_N.t61 0.152
R5848 OUT_N.n52 OUT_N.t32 0.152
R5849 OUT_N.n53 OUT_N.t0 0.152
R5850 OUT_N.n54 OUT_N.t33 0.152
R5851 OUT_N.n38 OUT_N.t14 0.152
R5852 OUT_N.n39 OUT_N.t43 0.152
R5853 OUT_N.n40 OUT_N.t20 0.152
R5854 OUT_N.n41 OUT_N.t16 0.152
R5855 OUT_N.n42 OUT_N.t45 0.152
R5856 OUT_N.n43 OUT_N.t26 0.152
R5857 OUT_N.n44 OUT_N.t59 0.152
R5858 OUT_N.n45 OUT_N.t29 0.152
R5859 OUT_N.n31 OUT_N.t44 0.152
R5860 OUT_N.n32 OUT_N.t15 0.152
R5861 OUT_N.n33 OUT_N.t49 0.152
R5862 OUT_N.n34 OUT_N.t46 0.152
R5863 OUT_N.n35 OUT_N.t17 0.152
R5864 OUT_N.n36 OUT_N.t36 0.152
R5865 OUT_N.n37 OUT_N.t7 0.152
R5866 OUT_N.n24 OUT_N.t50 0.152
R5867 OUT_N.n25 OUT_N.t22 0.152
R5868 OUT_N.n26 OUT_N.t56 0.152
R5869 OUT_N.n27 OUT_N.t52 0.152
R5870 OUT_N.n28 OUT_N.t24 0.152
R5871 OUT_N.n29 OUT_N.t35 0.152
R5872 OUT_N.n30 OUT_N.t6 0.152
R5873 OUT_N.n18 OUT_N.t8 0.152
R5874 OUT_N.n19 OUT_N.t40 0.152
R5875 OUT_N.n20 OUT_N.t12 0.152
R5876 OUT_N.n21 OUT_N.t9 0.152
R5877 OUT_N.n22 OUT_N.t42 0.152
R5878 OUT_N.n23 OUT_N.t53 0.152
R5879 OUT_N.n12 OUT_N.t34 0.152
R5880 OUT_N.n13 OUT_N.t3 0.152
R5881 OUT_N.n14 OUT_N.t39 0.152
R5882 OUT_N.n15 OUT_N.t38 0.152
R5883 OUT_N.n16 OUT_N.t4 0.152
R5884 OUT_N.n17 OUT_N.t55 0.152
R5885 OUT_N.n6 OUT_N.t51 0.152
R5886 OUT_N.n7 OUT_N.t23 0.152
R5887 OUT_N.n8 OUT_N.t57 0.152
R5888 OUT_N.n9 OUT_N.t54 0.152
R5889 OUT_N.n10 OUT_N.t25 0.152
R5890 OUT_N.n11 OUT_N.t11 0.152
R5891 OUT_N.n0 OUT_N.t58 0.152
R5892 OUT_N.n1 OUT_N.t28 0.152
R5893 OUT_N.n2 OUT_N.t62 0.152
R5894 OUT_N.n3 OUT_N.t60 0.152
R5895 OUT_N.n4 OUT_N.t30 0.152
R5896 OUT_N.n5 OUT_N.t10 0.152
R5897 a_1706_15242.n26 a_1706_15242.t0 10.181
R5898 a_1706_15242.n18 a_1706_15242.t1 10.181
R5899 a_1706_15242.t2 a_1706_15242.n39 9.68
R5900 a_1706_15242.n3 a_1706_15242.n2 9.302
R5901 a_1706_15242.n13 a_1706_15242.n12 9.302
R5902 a_1706_15242.n32 a_1706_15242.n31 9.3
R5903 a_1706_15242.n34 a_1706_15242.n33 9.3
R5904 a_1706_15242.n7 a_1706_15242.n6 9.3
R5905 a_1706_15242.n5 a_1706_15242.n4 9.3
R5906 a_1706_15242.n36 a_1706_15242.n35 9
R5907 a_1706_15242.n9 a_1706_15242.n8 9
R5908 a_1706_15242.n27 a_1706_15242.n25 7.729
R5909 a_1706_15242.n19 a_1706_15242.n17 7.729
R5910 a_1706_15242.n27 a_1706_15242.n26 6.296
R5911 a_1706_15242.n19 a_1706_15242.n18 6.296
R5912 a_1706_15242.n30 a_1706_15242.n3 4.508
R5913 a_1706_15242.n14 a_1706_15242.n13 4.508
R5914 a_1706_15242.n37 a_1706_15242.n36 4.496
R5915 a_1706_15242.n21 a_1706_15242.n20 4.496
R5916 a_1706_15242.n29 a_1706_15242.n28 4.495
R5917 a_1706_15242.n10 a_1706_15242.n9 4.495
R5918 a_1706_15242.n14 a_1706_15242.n11 4.494
R5919 a_1706_15242.n30 a_1706_15242.n1 4.494
R5920 a_1706_15242.n39 a_1706_15242.t3 1.087
R5921 a_1706_15242.n25 a_1706_15242.n24 0.536
R5922 a_1706_15242.n17 a_1706_15242.n16 0.536
R5923 a_1706_15242.n39 a_1706_15242.n38 0.255
R5924 a_1706_15242.n28 a_1706_15242.n27 0.151
R5925 a_1706_15242.n20 a_1706_15242.n19 0.151
R5926 a_1706_15242.n23 a_1706_15242.n22 0.125
R5927 a_1706_15242.n34 a_1706_15242.n32 0.028
R5928 a_1706_15242.n7 a_1706_15242.n5 0.028
R5929 a_1706_15242.n1 a_1706_15242.n0 0.025
R5930 a_1706_15242.n20 a_1706_15242.n15 0.024
R5931 a_1706_15242.n36 a_1706_15242.n34 0.012
R5932 a_1706_15242.n9 a_1706_15242.n7 0.012
R5933 a_1706_15242.n29 a_1706_15242.n23 0.011
R5934 a_1706_15242.n30 a_1706_15242.n29 0.011
R5935 a_1706_15242.n14 a_1706_15242.n10 0.011
R5936 a_1706_15242.n38 a_1706_15242.n37 0.01
R5937 a_1706_15242.n22 a_1706_15242.n21 0.01
R5938 a_1706_15242.n21 a_1706_15242.n14 0.01
R5939 a_1706_15242.n37 a_1706_15242.n30 0.01
R5940 bit5.n0 bit5.t46 552.693
R5941 bit5.n3 bit5.t26 300.446
R5942 bit5.n1 bit5.t22 300.446
R5943 bit5.n10 bit5.t33 300.446
R5944 bit5.n8 bit5.t48 300.446
R5945 bit5.n18 bit5.t62 300.446
R5946 bit5.n16 bit5.t55 300.446
R5947 bit5.n26 bit5.t11 300.446
R5948 bit5.n24 bit5.t23 300.446
R5949 bit5.n34 bit5.t56 300.446
R5950 bit5.n32 bit5.t53 300.446
R5951 bit5.n42 bit5.t14 300.446
R5952 bit5.n40 bit5.t24 300.446
R5953 bit5.n50 bit5.t37 300.446
R5954 bit5.n48 bit5.t31 300.446
R5955 bit5.n60 bit5.t49 300.446
R5956 bit5.n58 bit5.t59 300.446
R5957 bit5.n66 bit5.t52 300.446
R5958 bit5.n64 bit5.t45 300.446
R5959 bit5.n73 bit5.t61 300.446
R5960 bit5.n71 bit5.t5 300.446
R5961 bit5.n81 bit5.t20 300.446
R5962 bit5.n79 bit5.t15 300.446
R5963 bit5.n89 bit5.t32 300.446
R5964 bit5.n87 bit5.t47 300.446
R5965 bit5.n97 bit5.t16 300.446
R5966 bit5.n95 bit5.t13 300.446
R5967 bit5.n105 bit5.t36 300.446
R5968 bit5.n103 bit5.t50 300.446
R5969 bit5.n113 bit5.t64 300.446
R5970 bit5.n111 bit5.t58 300.446
R5971 bit5.n121 bit5.t3 300.446
R5972 bit5.n119 bit5.t18 300.446
R5973 bit5.n130 bit5.t9 300.446
R5974 bit5.n128 bit5.t2 300.446
R5975 bit5.n137 bit5.t19 300.446
R5976 bit5.n135 bit5.t29 300.446
R5977 bit5.n145 bit5.t42 300.446
R5978 bit5.n143 bit5.t38 300.446
R5979 bit5.n153 bit5.t60 300.446
R5980 bit5.n151 bit5.t4 300.446
R5981 bit5.n161 bit5.t40 300.446
R5982 bit5.n159 bit5.t35 300.446
R5983 bit5.n169 bit5.t63 300.446
R5984 bit5.n167 bit5.t7 300.446
R5985 bit5.n177 bit5.t21 300.446
R5986 bit5.n175 bit5.t17 300.446
R5987 bit5.n185 bit5.t27 300.446
R5988 bit5.n183 bit5.t41 300.446
R5989 bit5.n195 bit5.t54 300.446
R5990 bit5.n193 bit5.t34 300.446
R5991 bit5.n203 bit5.t30 300.446
R5992 bit5.n201 bit5.t28 300.446
R5993 bit5.n211 bit5.t25 300.446
R5994 bit5.n209 bit5.t6 300.446
R5995 bit5.n219 bit5.t0 300.446
R5996 bit5.n217 bit5.t65 300.446
R5997 bit5.n227 bit5.t12 300.446
R5998 bit5.n225 bit5.t57 300.446
R5999 bit5.n235 bit5.t10 300.446
R6000 bit5.n233 bit5.t8 300.446
R6001 bit5.n243 bit5.t1 300.446
R6002 bit5.n241 bit5.t51 300.446
R6003 bit5.n251 bit5.t44 300.446
R6004 bit5.n249 bit5.t43 300.446
R6005 bit5.n0 bit5.t39 279.56
R6006 bit5.n192 bit5.n0 119.784
R6007 bit5.n59 bit5.n58 27.537
R6008 bit5.n6 bit5.n3 27.536
R6009 bit5.n13 bit5.n10 27.536
R6010 bit5.n21 bit5.n18 27.536
R6011 bit5.n29 bit5.n26 27.536
R6012 bit5.n37 bit5.n34 27.536
R6013 bit5.n45 bit5.n42 27.536
R6014 bit5.n53 bit5.n50 27.536
R6015 bit5.n69 bit5.n66 27.536
R6016 bit5.n76 bit5.n73 27.536
R6017 bit5.n84 bit5.n81 27.536
R6018 bit5.n92 bit5.n89 27.536
R6019 bit5.n100 bit5.n97 27.536
R6020 bit5.n108 bit5.n105 27.536
R6021 bit5.n116 bit5.n113 27.536
R6022 bit5.n124 bit5.n121 27.536
R6023 bit5.n133 bit5.n130 27.536
R6024 bit5.n140 bit5.n137 27.536
R6025 bit5.n148 bit5.n145 27.536
R6026 bit5.n156 bit5.n153 27.536
R6027 bit5.n164 bit5.n161 27.536
R6028 bit5.n172 bit5.n169 27.536
R6029 bit5.n180 bit5.n177 27.536
R6030 bit5.n188 bit5.n185 27.536
R6031 bit5.n198 bit5.n195 27.536
R6032 bit5.n206 bit5.n203 27.536
R6033 bit5.n214 bit5.n211 27.536
R6034 bit5.n222 bit5.n219 27.536
R6035 bit5.n230 bit5.n227 27.536
R6036 bit5.n238 bit5.n235 27.536
R6037 bit5.n246 bit5.n243 27.536
R6038 bit5.n254 bit5.n251 27.536
R6039 bit5.n2 bit5.n1 24.127
R6040 bit5.n9 bit5.n8 24.127
R6041 bit5.n17 bit5.n16 24.127
R6042 bit5.n25 bit5.n24 24.127
R6043 bit5.n33 bit5.n32 24.127
R6044 bit5.n41 bit5.n40 24.127
R6045 bit5.n49 bit5.n48 24.127
R6046 bit5.n61 bit5.n60 24.127
R6047 bit5.n65 bit5.n64 24.127
R6048 bit5.n72 bit5.n71 24.127
R6049 bit5.n80 bit5.n79 24.127
R6050 bit5.n88 bit5.n87 24.127
R6051 bit5.n96 bit5.n95 24.127
R6052 bit5.n104 bit5.n103 24.127
R6053 bit5.n112 bit5.n111 24.127
R6054 bit5.n120 bit5.n119 24.127
R6055 bit5.n129 bit5.n128 24.127
R6056 bit5.n136 bit5.n135 24.127
R6057 bit5.n144 bit5.n143 24.127
R6058 bit5.n152 bit5.n151 24.127
R6059 bit5.n160 bit5.n159 24.127
R6060 bit5.n168 bit5.n167 24.127
R6061 bit5.n176 bit5.n175 24.127
R6062 bit5.n184 bit5.n183 24.127
R6063 bit5.n194 bit5.n193 24.127
R6064 bit5.n202 bit5.n201 24.127
R6065 bit5.n210 bit5.n209 24.127
R6066 bit5.n218 bit5.n217 24.127
R6067 bit5.n226 bit5.n225 24.127
R6068 bit5.n234 bit5.n233 24.127
R6069 bit5.n242 bit5.n241 24.127
R6070 bit5.n250 bit5.n249 24.127
R6071 bit5.n5 bit5.n4 8.764
R6072 bit5.n12 bit5.n11 8.764
R6073 bit5.n20 bit5.n19 8.764
R6074 bit5.n28 bit5.n27 8.764
R6075 bit5.n36 bit5.n35 8.764
R6076 bit5.n44 bit5.n43 8.764
R6077 bit5.n52 bit5.n51 8.764
R6078 bit5.n57 bit5.n56 8.764
R6079 bit5.n68 bit5.n67 8.764
R6080 bit5.n75 bit5.n74 8.764
R6081 bit5.n83 bit5.n82 8.764
R6082 bit5.n91 bit5.n90 8.764
R6083 bit5.n99 bit5.n98 8.764
R6084 bit5.n107 bit5.n106 8.764
R6085 bit5.n115 bit5.n114 8.764
R6086 bit5.n123 bit5.n122 8.764
R6087 bit5.n132 bit5.n131 8.764
R6088 bit5.n139 bit5.n138 8.764
R6089 bit5.n147 bit5.n146 8.764
R6090 bit5.n155 bit5.n154 8.764
R6091 bit5.n163 bit5.n162 8.764
R6092 bit5.n171 bit5.n170 8.764
R6093 bit5.n179 bit5.n178 8.764
R6094 bit5.n187 bit5.n186 8.764
R6095 bit5.n197 bit5.n196 8.764
R6096 bit5.n205 bit5.n204 8.764
R6097 bit5.n213 bit5.n212 8.764
R6098 bit5.n221 bit5.n220 8.764
R6099 bit5.n229 bit5.n228 8.764
R6100 bit5.n237 bit5.n236 8.764
R6101 bit5.n245 bit5.n244 8.764
R6102 bit5.n253 bit5.n252 8.764
R6103 bit5.n15 bit5.n7 5.287
R6104 bit5.n78 bit5.n70 5.287
R6105 bit5.n142 bit5.n134 5.287
R6106 bit5.n127 bit5.n63 5.006
R6107 bit5.n23 bit5.n15 4.958
R6108 bit5.n31 bit5.n23 4.958
R6109 bit5.n39 bit5.n31 4.958
R6110 bit5.n47 bit5.n39 4.958
R6111 bit5.n55 bit5.n47 4.958
R6112 bit5.n63 bit5.n55 4.958
R6113 bit5.n86 bit5.n78 4.958
R6114 bit5.n94 bit5.n86 4.958
R6115 bit5.n102 bit5.n94 4.958
R6116 bit5.n110 bit5.n102 4.958
R6117 bit5.n118 bit5.n110 4.958
R6118 bit5.n126 bit5.n118 4.958
R6119 bit5.n150 bit5.n142 4.958
R6120 bit5.n158 bit5.n150 4.958
R6121 bit5.n166 bit5.n158 4.958
R6122 bit5.n174 bit5.n166 4.958
R6123 bit5.n182 bit5.n174 4.958
R6124 bit5.n190 bit5.n182 4.958
R6125 bit5.n208 bit5.n200 4.958
R6126 bit5.n216 bit5.n208 4.958
R6127 bit5.n224 bit5.n216 4.958
R6128 bit5.n232 bit5.n224 4.958
R6129 bit5.n240 bit5.n232 4.958
R6130 bit5.n248 bit5.n240 4.958
R6131 bit5.n256 bit5.n248 4.958
R6132 bit5.n7 bit5.n2 4.662
R6133 bit5.n14 bit5.n9 4.662
R6134 bit5.n22 bit5.n17 4.662
R6135 bit5.n30 bit5.n25 4.662
R6136 bit5.n38 bit5.n33 4.662
R6137 bit5.n46 bit5.n41 4.662
R6138 bit5.n54 bit5.n49 4.662
R6139 bit5.n70 bit5.n65 4.662
R6140 bit5.n77 bit5.n72 4.662
R6141 bit5.n85 bit5.n80 4.662
R6142 bit5.n93 bit5.n88 4.662
R6143 bit5.n101 bit5.n96 4.662
R6144 bit5.n109 bit5.n104 4.662
R6145 bit5.n117 bit5.n112 4.662
R6146 bit5.n125 bit5.n120 4.662
R6147 bit5.n134 bit5.n129 4.662
R6148 bit5.n141 bit5.n136 4.662
R6149 bit5.n149 bit5.n144 4.662
R6150 bit5.n157 bit5.n152 4.662
R6151 bit5.n165 bit5.n160 4.662
R6152 bit5.n173 bit5.n168 4.662
R6153 bit5.n181 bit5.n176 4.662
R6154 bit5.n189 bit5.n184 4.662
R6155 bit5.n199 bit5.n194 4.662
R6156 bit5.n207 bit5.n202 4.662
R6157 bit5.n215 bit5.n210 4.662
R6158 bit5.n223 bit5.n218 4.662
R6159 bit5.n231 bit5.n226 4.662
R6160 bit5.n239 bit5.n234 4.662
R6161 bit5.n247 bit5.n242 4.662
R6162 bit5.n255 bit5.n250 4.662
R6163 bit5.n62 bit5.n61 4.661
R6164 bit5.n6 bit5.n5 3.401
R6165 bit5.n13 bit5.n12 3.401
R6166 bit5.n21 bit5.n20 3.401
R6167 bit5.n29 bit5.n28 3.401
R6168 bit5.n37 bit5.n36 3.401
R6169 bit5.n45 bit5.n44 3.401
R6170 bit5.n53 bit5.n52 3.401
R6171 bit5.n69 bit5.n68 3.401
R6172 bit5.n76 bit5.n75 3.401
R6173 bit5.n84 bit5.n83 3.401
R6174 bit5.n92 bit5.n91 3.401
R6175 bit5.n100 bit5.n99 3.401
R6176 bit5.n108 bit5.n107 3.401
R6177 bit5.n116 bit5.n115 3.401
R6178 bit5.n124 bit5.n123 3.401
R6179 bit5.n133 bit5.n132 3.401
R6180 bit5.n140 bit5.n139 3.401
R6181 bit5.n148 bit5.n147 3.401
R6182 bit5.n156 bit5.n155 3.401
R6183 bit5.n164 bit5.n163 3.401
R6184 bit5.n172 bit5.n171 3.401
R6185 bit5.n180 bit5.n179 3.401
R6186 bit5.n188 bit5.n187 3.401
R6187 bit5.n198 bit5.n197 3.401
R6188 bit5.n206 bit5.n205 3.401
R6189 bit5.n214 bit5.n213 3.401
R6190 bit5.n222 bit5.n221 3.401
R6191 bit5.n230 bit5.n229 3.401
R6192 bit5.n238 bit5.n237 3.401
R6193 bit5.n246 bit5.n245 3.401
R6194 bit5.n254 bit5.n253 3.401
R6195 bit5.n59 bit5.n57 3.401
R6196 bit5.n200 bit5.n192 3.02
R6197 bit5 bit5.n256 2.986
R6198 bit5.n127 bit5.n126 2.59
R6199 bit5.n191 bit5.n190 2.59
R6200 bit5.n191 bit5.n127 2.416
R6201 bit5.n192 bit5.n191 1.986
R6202 bit5.n62 bit5.n59 0.626
R6203 bit5.n7 bit5.n6 0.626
R6204 bit5.n14 bit5.n13 0.626
R6205 bit5.n22 bit5.n21 0.626
R6206 bit5.n30 bit5.n29 0.626
R6207 bit5.n38 bit5.n37 0.626
R6208 bit5.n46 bit5.n45 0.626
R6209 bit5.n54 bit5.n53 0.626
R6210 bit5.n70 bit5.n69 0.626
R6211 bit5.n77 bit5.n76 0.626
R6212 bit5.n85 bit5.n84 0.626
R6213 bit5.n93 bit5.n92 0.626
R6214 bit5.n101 bit5.n100 0.626
R6215 bit5.n109 bit5.n108 0.626
R6216 bit5.n117 bit5.n116 0.626
R6217 bit5.n125 bit5.n124 0.626
R6218 bit5.n134 bit5.n133 0.626
R6219 bit5.n141 bit5.n140 0.626
R6220 bit5.n149 bit5.n148 0.626
R6221 bit5.n157 bit5.n156 0.626
R6222 bit5.n165 bit5.n164 0.626
R6223 bit5.n173 bit5.n172 0.626
R6224 bit5.n181 bit5.n180 0.626
R6225 bit5.n189 bit5.n188 0.626
R6226 bit5.n199 bit5.n198 0.626
R6227 bit5.n207 bit5.n206 0.626
R6228 bit5.n215 bit5.n214 0.626
R6229 bit5.n223 bit5.n222 0.626
R6230 bit5.n231 bit5.n230 0.626
R6231 bit5.n239 bit5.n238 0.626
R6232 bit5.n247 bit5.n246 0.626
R6233 bit5.n255 bit5.n254 0.626
R6234 bit5.n15 bit5.n14 0.329
R6235 bit5.n23 bit5.n22 0.329
R6236 bit5.n31 bit5.n30 0.329
R6237 bit5.n39 bit5.n38 0.329
R6238 bit5.n47 bit5.n46 0.329
R6239 bit5.n55 bit5.n54 0.329
R6240 bit5.n63 bit5.n62 0.329
R6241 bit5.n78 bit5.n77 0.329
R6242 bit5.n86 bit5.n85 0.329
R6243 bit5.n94 bit5.n93 0.329
R6244 bit5.n102 bit5.n101 0.329
R6245 bit5.n110 bit5.n109 0.329
R6246 bit5.n118 bit5.n117 0.329
R6247 bit5.n126 bit5.n125 0.329
R6248 bit5.n142 bit5.n141 0.329
R6249 bit5.n150 bit5.n149 0.329
R6250 bit5.n158 bit5.n157 0.329
R6251 bit5.n166 bit5.n165 0.329
R6252 bit5.n174 bit5.n173 0.329
R6253 bit5.n182 bit5.n181 0.329
R6254 bit5.n190 bit5.n189 0.329
R6255 bit5.n200 bit5.n199 0.329
R6256 bit5.n208 bit5.n207 0.329
R6257 bit5.n216 bit5.n215 0.329
R6258 bit5.n224 bit5.n223 0.329
R6259 bit5.n232 bit5.n231 0.329
R6260 bit5.n240 bit5.n239 0.329
R6261 bit5.n248 bit5.n247 0.329
R6262 bit5.n256 bit5.n255 0.329
R6263 a_12666_526.n10 a_12666_526.t3 10.181
R6264 a_12666_526.n10 a_12666_526.t2 10.181
R6265 a_12666_526.t1 a_12666_526.n18 9.68
R6266 a_12666_526.n1 a_12666_526.n0 9.302
R6267 a_12666_526.n7 a_12666_526.n6 9.3
R6268 a_12666_526.n5 a_12666_526.n4 9.3
R6269 a_12666_526.n9 a_12666_526.n8 9
R6270 a_12666_526.n13 a_12666_526.n12 7.729
R6271 a_12666_526.n13 a_12666_526.n10 6.296
R6272 a_12666_526.n16 a_12666_526.n1 4.508
R6273 a_12666_526.n15 a_12666_526.n14 4.501
R6274 a_12666_526.n15 a_12666_526.n9 4.501
R6275 a_12666_526.n16 a_12666_526.n3 4.494
R6276 a_12666_526.n18 a_12666_526.t0 1.259
R6277 a_12666_526.n12 a_12666_526.n11 0.536
R6278 a_12666_526.n18 a_12666_526.n17 0.415
R6279 a_12666_526.n14 a_12666_526.n13 0.151
R6280 a_12666_526.n7 a_12666_526.n5 0.028
R6281 a_12666_526.n3 a_12666_526.n2 0.025
R6282 a_12666_526.n17 a_12666_526.n16 0.021
R6283 a_12666_526.n9 a_12666_526.n7 0.012
R6284 a_12666_526.n16 a_12666_526.n15 0.006
R6285 a_12956_602.n26 a_12956_602.t2 10.181
R6286 a_12956_602.n18 a_12956_602.t1 10.181
R6287 a_12956_602.t0 a_12956_602.n39 9.68
R6288 a_12956_602.n3 a_12956_602.n2 9.302
R6289 a_12956_602.n13 a_12956_602.n12 9.302
R6290 a_12956_602.n32 a_12956_602.n31 9.3
R6291 a_12956_602.n34 a_12956_602.n33 9.3
R6292 a_12956_602.n7 a_12956_602.n6 9.3
R6293 a_12956_602.n5 a_12956_602.n4 9.3
R6294 a_12956_602.n36 a_12956_602.n35 9
R6295 a_12956_602.n9 a_12956_602.n8 9
R6296 a_12956_602.n27 a_12956_602.n25 7.729
R6297 a_12956_602.n19 a_12956_602.n17 7.729
R6298 a_12956_602.n27 a_12956_602.n26 6.296
R6299 a_12956_602.n19 a_12956_602.n18 6.296
R6300 a_12956_602.n30 a_12956_602.n3 4.508
R6301 a_12956_602.n14 a_12956_602.n13 4.508
R6302 a_12956_602.n37 a_12956_602.n36 4.496
R6303 a_12956_602.n21 a_12956_602.n20 4.496
R6304 a_12956_602.n29 a_12956_602.n28 4.495
R6305 a_12956_602.n10 a_12956_602.n9 4.495
R6306 a_12956_602.n14 a_12956_602.n11 4.494
R6307 a_12956_602.n30 a_12956_602.n1 4.494
R6308 a_12956_602.n39 a_12956_602.t3 1.087
R6309 a_12956_602.n25 a_12956_602.n24 0.536
R6310 a_12956_602.n17 a_12956_602.n16 0.536
R6311 a_12956_602.n39 a_12956_602.n38 0.255
R6312 a_12956_602.n28 a_12956_602.n27 0.151
R6313 a_12956_602.n20 a_12956_602.n19 0.151
R6314 a_12956_602.n23 a_12956_602.n22 0.125
R6315 a_12956_602.n34 a_12956_602.n32 0.028
R6316 a_12956_602.n7 a_12956_602.n5 0.028
R6317 a_12956_602.n1 a_12956_602.n0 0.025
R6318 a_12956_602.n20 a_12956_602.n15 0.024
R6319 a_12956_602.n36 a_12956_602.n34 0.012
R6320 a_12956_602.n9 a_12956_602.n7 0.012
R6321 a_12956_602.n29 a_12956_602.n23 0.011
R6322 a_12956_602.n30 a_12956_602.n29 0.011
R6323 a_12956_602.n14 a_12956_602.n10 0.011
R6324 a_12956_602.n38 a_12956_602.n37 0.01
R6325 a_12956_602.n22 a_12956_602.n21 0.01
R6326 a_12956_602.n21 a_12956_602.n14 0.01
R6327 a_12956_602.n37 a_12956_602.n30 0.01
R6328 a_1706_13412.n26 a_1706_13412.t0 10.181
R6329 a_1706_13412.n18 a_1706_13412.t1 10.181
R6330 a_1706_13412.t2 a_1706_13412.n39 9.68
R6331 a_1706_13412.n3 a_1706_13412.n2 9.302
R6332 a_1706_13412.n13 a_1706_13412.n12 9.302
R6333 a_1706_13412.n32 a_1706_13412.n31 9.3
R6334 a_1706_13412.n34 a_1706_13412.n33 9.3
R6335 a_1706_13412.n7 a_1706_13412.n6 9.3
R6336 a_1706_13412.n5 a_1706_13412.n4 9.3
R6337 a_1706_13412.n36 a_1706_13412.n35 9
R6338 a_1706_13412.n9 a_1706_13412.n8 9
R6339 a_1706_13412.n27 a_1706_13412.n25 7.729
R6340 a_1706_13412.n19 a_1706_13412.n17 7.729
R6341 a_1706_13412.n27 a_1706_13412.n26 6.296
R6342 a_1706_13412.n19 a_1706_13412.n18 6.296
R6343 a_1706_13412.n30 a_1706_13412.n3 4.508
R6344 a_1706_13412.n14 a_1706_13412.n13 4.508
R6345 a_1706_13412.n37 a_1706_13412.n36 4.496
R6346 a_1706_13412.n21 a_1706_13412.n20 4.496
R6347 a_1706_13412.n29 a_1706_13412.n28 4.495
R6348 a_1706_13412.n10 a_1706_13412.n9 4.495
R6349 a_1706_13412.n14 a_1706_13412.n11 4.494
R6350 a_1706_13412.n30 a_1706_13412.n1 4.494
R6351 a_1706_13412.n39 a_1706_13412.t3 1.087
R6352 a_1706_13412.n25 a_1706_13412.n24 0.536
R6353 a_1706_13412.n17 a_1706_13412.n16 0.536
R6354 a_1706_13412.n39 a_1706_13412.n38 0.255
R6355 a_1706_13412.n28 a_1706_13412.n27 0.151
R6356 a_1706_13412.n20 a_1706_13412.n19 0.151
R6357 a_1706_13412.n23 a_1706_13412.n22 0.125
R6358 a_1706_13412.n34 a_1706_13412.n32 0.028
R6359 a_1706_13412.n7 a_1706_13412.n5 0.028
R6360 a_1706_13412.n1 a_1706_13412.n0 0.025
R6361 a_1706_13412.n20 a_1706_13412.n15 0.024
R6362 a_1706_13412.n36 a_1706_13412.n34 0.012
R6363 a_1706_13412.n9 a_1706_13412.n7 0.012
R6364 a_1706_13412.n29 a_1706_13412.n23 0.011
R6365 a_1706_13412.n30 a_1706_13412.n29 0.011
R6366 a_1706_13412.n14 a_1706_13412.n10 0.011
R6367 a_1706_13412.n38 a_1706_13412.n37 0.01
R6368 a_1706_13412.n22 a_1706_13412.n21 0.01
R6369 a_1706_13412.n21 a_1706_13412.n14 0.01
R6370 a_1706_13412.n37 a_1706_13412.n30 0.01
R6371 a_n456_12816.t4 a_n456_12816.n7 139.026
R6372 a_n456_12816.n7 a_n456_12816.t3 85.389
R6373 a_n456_12816.n7 a_n456_12816.n6 55.674
R6374 a_n456_12816.n0 a_n456_12816.t2 10.163
R6375 a_n456_12816.n6 a_n456_12816.t9 9.587
R6376 a_n456_12816.n5 a_n456_12816.t8 9.587
R6377 a_n456_12816.n4 a_n456_12816.t5 9.587
R6378 a_n456_12816.n3 a_n456_12816.t7 9.587
R6379 a_n456_12816.n2 a_n456_12816.t0 9.587
R6380 a_n456_12816.n1 a_n456_12816.t6 9.587
R6381 a_n456_12816.n0 a_n456_12816.t1 9.587
R6382 a_n456_12816.n1 a_n456_12816.n0 2.353
R6383 a_n456_12816.n3 a_n456_12816.n2 2.353
R6384 a_n456_12816.n5 a_n456_12816.n4 2.353
R6385 a_n456_12816.n2 a_n456_12816.n1 0.576
R6386 a_n456_12816.n4 a_n456_12816.n3 0.576
R6387 a_n456_12816.n6 a_n456_12816.n5 0.576
R6388 a_1706_17072.n26 a_1706_17072.t0 10.181
R6389 a_1706_17072.n18 a_1706_17072.t1 10.181
R6390 a_1706_17072.t2 a_1706_17072.n39 9.68
R6391 a_1706_17072.n3 a_1706_17072.n2 9.302
R6392 a_1706_17072.n13 a_1706_17072.n12 9.302
R6393 a_1706_17072.n32 a_1706_17072.n31 9.3
R6394 a_1706_17072.n34 a_1706_17072.n33 9.3
R6395 a_1706_17072.n7 a_1706_17072.n6 9.3
R6396 a_1706_17072.n5 a_1706_17072.n4 9.3
R6397 a_1706_17072.n36 a_1706_17072.n35 9
R6398 a_1706_17072.n9 a_1706_17072.n8 9
R6399 a_1706_17072.n27 a_1706_17072.n25 7.729
R6400 a_1706_17072.n19 a_1706_17072.n17 7.729
R6401 a_1706_17072.n27 a_1706_17072.n26 6.296
R6402 a_1706_17072.n19 a_1706_17072.n18 6.296
R6403 a_1706_17072.n30 a_1706_17072.n3 4.508
R6404 a_1706_17072.n14 a_1706_17072.n13 4.508
R6405 a_1706_17072.n37 a_1706_17072.n36 4.496
R6406 a_1706_17072.n21 a_1706_17072.n20 4.496
R6407 a_1706_17072.n29 a_1706_17072.n28 4.495
R6408 a_1706_17072.n10 a_1706_17072.n9 4.495
R6409 a_1706_17072.n14 a_1706_17072.n11 4.494
R6410 a_1706_17072.n30 a_1706_17072.n1 4.494
R6411 a_1706_17072.n39 a_1706_17072.t3 1.087
R6412 a_1706_17072.n25 a_1706_17072.n24 0.536
R6413 a_1706_17072.n17 a_1706_17072.n16 0.536
R6414 a_1706_17072.n39 a_1706_17072.n38 0.255
R6415 a_1706_17072.n28 a_1706_17072.n27 0.151
R6416 a_1706_17072.n20 a_1706_17072.n19 0.151
R6417 a_1706_17072.n23 a_1706_17072.n22 0.125
R6418 a_1706_17072.n34 a_1706_17072.n32 0.028
R6419 a_1706_17072.n7 a_1706_17072.n5 0.028
R6420 a_1706_17072.n1 a_1706_17072.n0 0.025
R6421 a_1706_17072.n20 a_1706_17072.n15 0.024
R6422 a_1706_17072.n36 a_1706_17072.n34 0.012
R6423 a_1706_17072.n9 a_1706_17072.n7 0.012
R6424 a_1706_17072.n29 a_1706_17072.n23 0.011
R6425 a_1706_17072.n30 a_1706_17072.n29 0.011
R6426 a_1706_17072.n14 a_1706_17072.n10 0.011
R6427 a_1706_17072.n38 a_1706_17072.n37 0.01
R6428 a_1706_17072.n22 a_1706_17072.n21 0.01
R6429 a_1706_17072.n21 a_1706_17072.n14 0.01
R6430 a_1706_17072.n37 a_1706_17072.n30 0.01
R6431 a_n456_16476.t1 a_n456_16476.n1 139.026
R6432 a_n456_16476.n1 a_n456_16476.t0 85.389
R6433 a_n456_16476.n1 a_n456_16476.n0 55.674
R6434 a_n456_16476.n0 a_n456_16476.t3 10.163
R6435 a_n456_16476.n0 a_n456_16476.t2 9.587
R6436 a_24206_602.n26 a_24206_602.t2 10.181
R6437 a_24206_602.n18 a_24206_602.t1 10.181
R6438 a_24206_602.t0 a_24206_602.n39 9.68
R6439 a_24206_602.n3 a_24206_602.n2 9.302
R6440 a_24206_602.n13 a_24206_602.n12 9.302
R6441 a_24206_602.n32 a_24206_602.n31 9.3
R6442 a_24206_602.n34 a_24206_602.n33 9.3
R6443 a_24206_602.n7 a_24206_602.n6 9.3
R6444 a_24206_602.n5 a_24206_602.n4 9.3
R6445 a_24206_602.n36 a_24206_602.n35 9
R6446 a_24206_602.n9 a_24206_602.n8 9
R6447 a_24206_602.n27 a_24206_602.n25 7.729
R6448 a_24206_602.n19 a_24206_602.n17 7.729
R6449 a_24206_602.n27 a_24206_602.n26 6.296
R6450 a_24206_602.n19 a_24206_602.n18 6.296
R6451 a_24206_602.n30 a_24206_602.n3 4.508
R6452 a_24206_602.n14 a_24206_602.n13 4.508
R6453 a_24206_602.n37 a_24206_602.n36 4.496
R6454 a_24206_602.n21 a_24206_602.n20 4.496
R6455 a_24206_602.n29 a_24206_602.n28 4.495
R6456 a_24206_602.n10 a_24206_602.n9 4.495
R6457 a_24206_602.n14 a_24206_602.n11 4.494
R6458 a_24206_602.n30 a_24206_602.n1 4.494
R6459 a_24206_602.n39 a_24206_602.t3 1.087
R6460 a_24206_602.n25 a_24206_602.n24 0.536
R6461 a_24206_602.n17 a_24206_602.n16 0.536
R6462 a_24206_602.n39 a_24206_602.n38 0.255
R6463 a_24206_602.n28 a_24206_602.n27 0.151
R6464 a_24206_602.n20 a_24206_602.n19 0.151
R6465 a_24206_602.n23 a_24206_602.n22 0.125
R6466 a_24206_602.n34 a_24206_602.n32 0.028
R6467 a_24206_602.n7 a_24206_602.n5 0.028
R6468 a_24206_602.n1 a_24206_602.n0 0.025
R6469 a_24206_602.n20 a_24206_602.n15 0.024
R6470 a_24206_602.n36 a_24206_602.n34 0.012
R6471 a_24206_602.n9 a_24206_602.n7 0.012
R6472 a_24206_602.n29 a_24206_602.n23 0.011
R6473 a_24206_602.n30 a_24206_602.n29 0.011
R6474 a_24206_602.n14 a_24206_602.n10 0.011
R6475 a_24206_602.n38 a_24206_602.n37 0.01
R6476 a_24206_602.n22 a_24206_602.n21 0.01
R6477 a_24206_602.n21 a_24206_602.n14 0.01
R6478 a_24206_602.n37 a_24206_602.n30 0.01
R6479 a_1416_9676.n10 a_1416_9676.t0 10.181
R6480 a_1416_9676.n10 a_1416_9676.t1 10.181
R6481 a_1416_9676.t2 a_1416_9676.n18 9.68
R6482 a_1416_9676.n1 a_1416_9676.n0 9.302
R6483 a_1416_9676.n7 a_1416_9676.n6 9.3
R6484 a_1416_9676.n5 a_1416_9676.n4 9.3
R6485 a_1416_9676.n9 a_1416_9676.n8 9
R6486 a_1416_9676.n13 a_1416_9676.n12 7.729
R6487 a_1416_9676.n13 a_1416_9676.n10 6.296
R6488 a_1416_9676.n16 a_1416_9676.n1 4.508
R6489 a_1416_9676.n15 a_1416_9676.n14 4.501
R6490 a_1416_9676.n15 a_1416_9676.n9 4.501
R6491 a_1416_9676.n16 a_1416_9676.n3 4.494
R6492 a_1416_9676.n18 a_1416_9676.t3 1.259
R6493 a_1416_9676.n12 a_1416_9676.n11 0.536
R6494 a_1416_9676.n18 a_1416_9676.n17 0.415
R6495 a_1416_9676.n14 a_1416_9676.n13 0.151
R6496 a_1416_9676.n7 a_1416_9676.n5 0.028
R6497 a_1416_9676.n3 a_1416_9676.n2 0.025
R6498 a_1416_9676.n17 a_1416_9676.n16 0.021
R6499 a_1416_9676.n9 a_1416_9676.n7 0.012
R6500 a_1416_9676.n16 a_1416_9676.n15 0.006
R6501 a_12666_6016.n10 a_12666_6016.t2 10.181
R6502 a_12666_6016.n10 a_12666_6016.t3 10.181
R6503 a_12666_6016.t1 a_12666_6016.n18 9.68
R6504 a_12666_6016.n1 a_12666_6016.n0 9.302
R6505 a_12666_6016.n7 a_12666_6016.n6 9.3
R6506 a_12666_6016.n5 a_12666_6016.n4 9.3
R6507 a_12666_6016.n9 a_12666_6016.n8 9
R6508 a_12666_6016.n13 a_12666_6016.n12 7.729
R6509 a_12666_6016.n13 a_12666_6016.n10 6.296
R6510 a_12666_6016.n16 a_12666_6016.n1 4.508
R6511 a_12666_6016.n15 a_12666_6016.n14 4.501
R6512 a_12666_6016.n15 a_12666_6016.n9 4.501
R6513 a_12666_6016.n16 a_12666_6016.n3 4.494
R6514 a_12666_6016.n18 a_12666_6016.t0 1.259
R6515 a_12666_6016.n12 a_12666_6016.n11 0.536
R6516 a_12666_6016.n18 a_12666_6016.n17 0.415
R6517 a_12666_6016.n14 a_12666_6016.n13 0.151
R6518 a_12666_6016.n7 a_12666_6016.n5 0.028
R6519 a_12666_6016.n3 a_12666_6016.n2 0.025
R6520 a_12666_6016.n17 a_12666_6016.n16 0.021
R6521 a_12666_6016.n9 a_12666_6016.n7 0.012
R6522 a_12666_6016.n16 a_12666_6016.n15 0.006
R6523 a_16706_4262.n26 a_16706_4262.t0 10.181
R6524 a_16706_4262.n18 a_16706_4262.t1 10.181
R6525 a_16706_4262.t3 a_16706_4262.n39 9.68
R6526 a_16706_4262.n3 a_16706_4262.n2 9.302
R6527 a_16706_4262.n13 a_16706_4262.n12 9.302
R6528 a_16706_4262.n32 a_16706_4262.n31 9.3
R6529 a_16706_4262.n34 a_16706_4262.n33 9.3
R6530 a_16706_4262.n7 a_16706_4262.n6 9.3
R6531 a_16706_4262.n5 a_16706_4262.n4 9.3
R6532 a_16706_4262.n36 a_16706_4262.n35 9
R6533 a_16706_4262.n9 a_16706_4262.n8 9
R6534 a_16706_4262.n27 a_16706_4262.n25 7.729
R6535 a_16706_4262.n19 a_16706_4262.n17 7.729
R6536 a_16706_4262.n27 a_16706_4262.n26 6.296
R6537 a_16706_4262.n19 a_16706_4262.n18 6.296
R6538 a_16706_4262.n30 a_16706_4262.n3 4.508
R6539 a_16706_4262.n14 a_16706_4262.n13 4.508
R6540 a_16706_4262.n37 a_16706_4262.n36 4.496
R6541 a_16706_4262.n21 a_16706_4262.n20 4.496
R6542 a_16706_4262.n29 a_16706_4262.n28 4.495
R6543 a_16706_4262.n10 a_16706_4262.n9 4.495
R6544 a_16706_4262.n14 a_16706_4262.n11 4.494
R6545 a_16706_4262.n30 a_16706_4262.n1 4.494
R6546 a_16706_4262.n39 a_16706_4262.t2 1.087
R6547 a_16706_4262.n25 a_16706_4262.n24 0.536
R6548 a_16706_4262.n17 a_16706_4262.n16 0.536
R6549 a_16706_4262.n39 a_16706_4262.n38 0.255
R6550 a_16706_4262.n28 a_16706_4262.n27 0.151
R6551 a_16706_4262.n20 a_16706_4262.n19 0.151
R6552 a_16706_4262.n23 a_16706_4262.n22 0.125
R6553 a_16706_4262.n34 a_16706_4262.n32 0.028
R6554 a_16706_4262.n7 a_16706_4262.n5 0.028
R6555 a_16706_4262.n1 a_16706_4262.n0 0.025
R6556 a_16706_4262.n20 a_16706_4262.n15 0.024
R6557 a_16706_4262.n36 a_16706_4262.n34 0.012
R6558 a_16706_4262.n9 a_16706_4262.n7 0.012
R6559 a_16706_4262.n29 a_16706_4262.n23 0.011
R6560 a_16706_4262.n30 a_16706_4262.n29 0.011
R6561 a_16706_4262.n14 a_16706_4262.n10 0.011
R6562 a_16706_4262.n38 a_16706_4262.n37 0.01
R6563 a_16706_4262.n22 a_16706_4262.n21 0.01
R6564 a_16706_4262.n21 a_16706_4262.n14 0.01
R6565 a_16706_4262.n37 a_16706_4262.n30 0.01
R6566 a_n456_6.t64 a_n456_6.n63 139.026
R6567 a_n456_6.n63 a_n456_6.t63 85.389
R6568 a_n456_6.n63 a_n456_6.n62 54.072
R6569 a_n456_6.n15 a_n456_6.t41 10.163
R6570 a_n456_6.n30 a_n456_6.t12 10.163
R6571 a_n456_6.n46 a_n456_6.t57 10.163
R6572 a_n456_6.n0 a_n456_6.t2 10.163
R6573 a_n456_6.n29 a_n456_6.t54 9.587
R6574 a_n456_6.n28 a_n456_6.t34 9.587
R6575 a_n456_6.n27 a_n456_6.t62 9.587
R6576 a_n456_6.n26 a_n456_6.t52 9.587
R6577 a_n456_6.n25 a_n456_6.t46 9.587
R6578 a_n456_6.n24 a_n456_6.t44 9.587
R6579 a_n456_6.n23 a_n456_6.t35 9.587
R6580 a_n456_6.n22 a_n456_6.t21 9.587
R6581 a_n456_6.n21 a_n456_6.t15 9.587
R6582 a_n456_6.n20 a_n456_6.t10 9.587
R6583 a_n456_6.n19 a_n456_6.t50 9.587
R6584 a_n456_6.n18 a_n456_6.t24 9.587
R6585 a_n456_6.n17 a_n456_6.t18 9.587
R6586 a_n456_6.n16 a_n456_6.t13 9.587
R6587 a_n456_6.n15 a_n456_6.t6 9.587
R6588 a_n456_6.n44 a_n456_6.t7 9.587
R6589 a_n456_6.n43 a_n456_6.t3 9.587
R6590 a_n456_6.n42 a_n456_6.t1 9.587
R6591 a_n456_6.n41 a_n456_6.t27 9.587
R6592 a_n456_6.n40 a_n456_6.t20 9.587
R6593 a_n456_6.n39 a_n456_6.t17 9.587
R6594 a_n456_6.n38 a_n456_6.t49 9.587
R6595 a_n456_6.n37 a_n456_6.t58 9.587
R6596 a_n456_6.n36 a_n456_6.t40 9.587
R6597 a_n456_6.n35 a_n456_6.t65 9.587
R6598 a_n456_6.n34 a_n456_6.t25 9.587
R6599 a_n456_6.n33 a_n456_6.t32 9.587
R6600 a_n456_6.n32 a_n456_6.t36 9.587
R6601 a_n456_6.n31 a_n456_6.t61 9.587
R6602 a_n456_6.n30 a_n456_6.t31 9.587
R6603 a_n456_6.n60 a_n456_6.t53 9.587
R6604 a_n456_6.n59 a_n456_6.t33 9.587
R6605 a_n456_6.n58 a_n456_6.t37 9.587
R6606 a_n456_6.n57 a_n456_6.t51 9.587
R6607 a_n456_6.n56 a_n456_6.t45 9.587
R6608 a_n456_6.n55 a_n456_6.t43 9.587
R6609 a_n456_6.n54 a_n456_6.t39 9.587
R6610 a_n456_6.n53 a_n456_6.t19 9.587
R6611 a_n456_6.n52 a_n456_6.t14 9.587
R6612 a_n456_6.n51 a_n456_6.t8 9.587
R6613 a_n456_6.n50 a_n456_6.t47 9.587
R6614 a_n456_6.n49 a_n456_6.t23 9.587
R6615 a_n456_6.n48 a_n456_6.t16 9.587
R6616 a_n456_6.n47 a_n456_6.t11 9.587
R6617 a_n456_6.n46 a_n456_6.t5 9.587
R6618 a_n456_6.n14 a_n456_6.t26 9.587
R6619 a_n456_6.n13 a_n456_6.t38 9.587
R6620 a_n456_6.n12 a_n456_6.t0 9.587
R6621 a_n456_6.n11 a_n456_6.t56 9.587
R6622 a_n456_6.n10 a_n456_6.t9 9.587
R6623 a_n456_6.n9 a_n456_6.t28 9.587
R6624 a_n456_6.n8 a_n456_6.t55 9.587
R6625 a_n456_6.n7 a_n456_6.t22 9.587
R6626 a_n456_6.n6 a_n456_6.t60 9.587
R6627 a_n456_6.n5 a_n456_6.t48 9.587
R6628 a_n456_6.n4 a_n456_6.t59 9.587
R6629 a_n456_6.n3 a_n456_6.t29 9.587
R6630 a_n456_6.n2 a_n456_6.t42 9.587
R6631 a_n456_6.n1 a_n456_6.t4 9.587
R6632 a_n456_6.n0 a_n456_6.t30 9.587
R6633 a_n456_6.n45 a_n456_6.n29 6.828
R6634 a_n456_6.n62 a_n456_6.n61 5.225
R6635 a_n456_6.n61 a_n456_6.n45 5.218
R6636 a_n456_6.n16 a_n456_6.n15 2.353
R6637 a_n456_6.n18 a_n456_6.n17 2.353
R6638 a_n456_6.n20 a_n456_6.n19 2.353
R6639 a_n456_6.n22 a_n456_6.n21 2.353
R6640 a_n456_6.n24 a_n456_6.n23 2.353
R6641 a_n456_6.n26 a_n456_6.n25 2.353
R6642 a_n456_6.n28 a_n456_6.n27 2.353
R6643 a_n456_6.n31 a_n456_6.n30 2.353
R6644 a_n456_6.n33 a_n456_6.n32 2.353
R6645 a_n456_6.n35 a_n456_6.n34 2.353
R6646 a_n456_6.n37 a_n456_6.n36 2.353
R6647 a_n456_6.n39 a_n456_6.n38 2.353
R6648 a_n456_6.n41 a_n456_6.n40 2.353
R6649 a_n456_6.n43 a_n456_6.n42 2.353
R6650 a_n456_6.n47 a_n456_6.n46 2.353
R6651 a_n456_6.n49 a_n456_6.n48 2.353
R6652 a_n456_6.n51 a_n456_6.n50 2.353
R6653 a_n456_6.n53 a_n456_6.n52 2.353
R6654 a_n456_6.n55 a_n456_6.n54 2.353
R6655 a_n456_6.n57 a_n456_6.n56 2.353
R6656 a_n456_6.n59 a_n456_6.n58 2.353
R6657 a_n456_6.n1 a_n456_6.n0 2.353
R6658 a_n456_6.n3 a_n456_6.n2 2.353
R6659 a_n456_6.n5 a_n456_6.n4 2.353
R6660 a_n456_6.n7 a_n456_6.n6 2.353
R6661 a_n456_6.n9 a_n456_6.n8 2.353
R6662 a_n456_6.n11 a_n456_6.n10 2.353
R6663 a_n456_6.n13 a_n456_6.n12 2.353
R6664 a_n456_6.n45 a_n456_6.n44 1.61
R6665 a_n456_6.n61 a_n456_6.n60 1.61
R6666 a_n456_6.n62 a_n456_6.n14 1.602
R6667 a_n456_6.n17 a_n456_6.n16 0.576
R6668 a_n456_6.n19 a_n456_6.n18 0.576
R6669 a_n456_6.n21 a_n456_6.n20 0.576
R6670 a_n456_6.n23 a_n456_6.n22 0.576
R6671 a_n456_6.n25 a_n456_6.n24 0.576
R6672 a_n456_6.n27 a_n456_6.n26 0.576
R6673 a_n456_6.n29 a_n456_6.n28 0.576
R6674 a_n456_6.n32 a_n456_6.n31 0.576
R6675 a_n456_6.n34 a_n456_6.n33 0.576
R6676 a_n456_6.n36 a_n456_6.n35 0.576
R6677 a_n456_6.n38 a_n456_6.n37 0.576
R6678 a_n456_6.n40 a_n456_6.n39 0.576
R6679 a_n456_6.n42 a_n456_6.n41 0.576
R6680 a_n456_6.n44 a_n456_6.n43 0.576
R6681 a_n456_6.n48 a_n456_6.n47 0.576
R6682 a_n456_6.n50 a_n456_6.n49 0.576
R6683 a_n456_6.n52 a_n456_6.n51 0.576
R6684 a_n456_6.n54 a_n456_6.n53 0.576
R6685 a_n456_6.n56 a_n456_6.n55 0.576
R6686 a_n456_6.n58 a_n456_6.n57 0.576
R6687 a_n456_6.n60 a_n456_6.n59 0.576
R6688 a_n456_6.n2 a_n456_6.n1 0.576
R6689 a_n456_6.n4 a_n456_6.n3 0.576
R6690 a_n456_6.n6 a_n456_6.n5 0.576
R6691 a_n456_6.n8 a_n456_6.n7 0.576
R6692 a_n456_6.n10 a_n456_6.n9 0.576
R6693 a_n456_6.n12 a_n456_6.n11 0.576
R6694 a_n456_6.n14 a_n456_6.n13 0.576
R6695 a_8916_7846.n10 a_8916_7846.t0 10.181
R6696 a_8916_7846.n10 a_8916_7846.t1 10.181
R6697 a_8916_7846.t3 a_8916_7846.n18 9.68
R6698 a_8916_7846.n1 a_8916_7846.n0 9.302
R6699 a_8916_7846.n7 a_8916_7846.n6 9.3
R6700 a_8916_7846.n5 a_8916_7846.n4 9.3
R6701 a_8916_7846.n9 a_8916_7846.n8 9
R6702 a_8916_7846.n13 a_8916_7846.n12 7.729
R6703 a_8916_7846.n13 a_8916_7846.n10 6.296
R6704 a_8916_7846.n16 a_8916_7846.n1 4.508
R6705 a_8916_7846.n15 a_8916_7846.n14 4.501
R6706 a_8916_7846.n15 a_8916_7846.n9 4.501
R6707 a_8916_7846.n16 a_8916_7846.n3 4.494
R6708 a_8916_7846.n18 a_8916_7846.t2 1.259
R6709 a_8916_7846.n12 a_8916_7846.n11 0.536
R6710 a_8916_7846.n18 a_8916_7846.n17 0.415
R6711 a_8916_7846.n14 a_8916_7846.n13 0.151
R6712 a_8916_7846.n7 a_8916_7846.n5 0.028
R6713 a_8916_7846.n3 a_8916_7846.n2 0.025
R6714 a_8916_7846.n17 a_8916_7846.n16 0.021
R6715 a_8916_7846.n9 a_8916_7846.n7 0.012
R6716 a_8916_7846.n16 a_8916_7846.n15 0.006
R6717 a_n456_7326.t0 a_n456_7326.n31 139.026
R6718 a_n456_7326.n31 a_n456_7326.t1 85.389
R6719 a_n456_7326.n31 a_n456_7326.n30 54.072
R6720 a_n456_7326.n0 a_n456_7326.t9 10.163
R6721 a_n456_7326.n15 a_n456_7326.t16 10.163
R6722 a_n456_7326.n14 a_n456_7326.t15 9.587
R6723 a_n456_7326.n13 a_n456_7326.t11 9.587
R6724 a_n456_7326.n12 a_n456_7326.t14 9.587
R6725 a_n456_7326.n11 a_n456_7326.t20 9.587
R6726 a_n456_7326.n10 a_n456_7326.t25 9.587
R6727 a_n456_7326.n9 a_n456_7326.t19 9.587
R6728 a_n456_7326.n8 a_n456_7326.t31 9.587
R6729 a_n456_7326.n7 a_n456_7326.t6 9.587
R6730 a_n456_7326.n6 a_n456_7326.t10 9.587
R6731 a_n456_7326.n5 a_n456_7326.t5 9.587
R6732 a_n456_7326.n4 a_n456_7326.t18 9.587
R6733 a_n456_7326.n3 a_n456_7326.t2 9.587
R6734 a_n456_7326.n2 a_n456_7326.t4 9.587
R6735 a_n456_7326.n1 a_n456_7326.t30 9.587
R6736 a_n456_7326.n0 a_n456_7326.t3 9.587
R6737 a_n456_7326.n29 a_n456_7326.t13 9.587
R6738 a_n456_7326.n28 a_n456_7326.t12 9.587
R6739 a_n456_7326.n27 a_n456_7326.t8 9.587
R6740 a_n456_7326.n26 a_n456_7326.t23 9.587
R6741 a_n456_7326.n25 a_n456_7326.t32 9.587
R6742 a_n456_7326.n24 a_n456_7326.t17 9.587
R6743 a_n456_7326.n23 a_n456_7326.t7 9.587
R6744 a_n456_7326.n22 a_n456_7326.t28 9.587
R6745 a_n456_7326.n21 a_n456_7326.t26 9.587
R6746 a_n456_7326.n20 a_n456_7326.t33 9.587
R6747 a_n456_7326.n19 a_n456_7326.t22 9.587
R6748 a_n456_7326.n18 a_n456_7326.t29 9.587
R6749 a_n456_7326.n17 a_n456_7326.t27 9.587
R6750 a_n456_7326.n16 a_n456_7326.t24 9.587
R6751 a_n456_7326.n15 a_n456_7326.t21 9.587
R6752 a_n456_7326.n30 a_n456_7326.n14 5.081
R6753 a_n456_7326.n1 a_n456_7326.n0 2.353
R6754 a_n456_7326.n3 a_n456_7326.n2 2.353
R6755 a_n456_7326.n5 a_n456_7326.n4 2.353
R6756 a_n456_7326.n7 a_n456_7326.n6 2.353
R6757 a_n456_7326.n9 a_n456_7326.n8 2.353
R6758 a_n456_7326.n11 a_n456_7326.n10 2.353
R6759 a_n456_7326.n13 a_n456_7326.n12 2.353
R6760 a_n456_7326.n16 a_n456_7326.n15 2.353
R6761 a_n456_7326.n18 a_n456_7326.n17 2.353
R6762 a_n456_7326.n20 a_n456_7326.n19 2.353
R6763 a_n456_7326.n22 a_n456_7326.n21 2.353
R6764 a_n456_7326.n24 a_n456_7326.n23 2.353
R6765 a_n456_7326.n26 a_n456_7326.n25 2.353
R6766 a_n456_7326.n28 a_n456_7326.n27 2.353
R6767 a_n456_7326.n30 a_n456_7326.n29 1.602
R6768 a_n456_7326.n2 a_n456_7326.n1 0.576
R6769 a_n456_7326.n4 a_n456_7326.n3 0.576
R6770 a_n456_7326.n6 a_n456_7326.n5 0.576
R6771 a_n456_7326.n8 a_n456_7326.n7 0.576
R6772 a_n456_7326.n10 a_n456_7326.n9 0.576
R6773 a_n456_7326.n12 a_n456_7326.n11 0.576
R6774 a_n456_7326.n14 a_n456_7326.n13 0.576
R6775 a_n456_7326.n17 a_n456_7326.n16 0.576
R6776 a_n456_7326.n19 a_n456_7326.n18 0.576
R6777 a_n456_7326.n21 a_n456_7326.n20 0.576
R6778 a_n456_7326.n23 a_n456_7326.n22 0.576
R6779 a_n456_7326.n25 a_n456_7326.n24 0.576
R6780 a_n456_7326.n27 a_n456_7326.n26 0.576
R6781 a_n456_7326.n29 a_n456_7326.n28 0.576
R6782 a_1416_13336.n10 a_1416_13336.t2 10.181
R6783 a_1416_13336.n10 a_1416_13336.t1 10.181
R6784 a_1416_13336.t3 a_1416_13336.n18 9.68
R6785 a_1416_13336.n1 a_1416_13336.n0 9.302
R6786 a_1416_13336.n7 a_1416_13336.n6 9.3
R6787 a_1416_13336.n5 a_1416_13336.n4 9.3
R6788 a_1416_13336.n9 a_1416_13336.n8 9
R6789 a_1416_13336.n13 a_1416_13336.n12 7.729
R6790 a_1416_13336.n13 a_1416_13336.n10 6.296
R6791 a_1416_13336.n16 a_1416_13336.n1 4.508
R6792 a_1416_13336.n15 a_1416_13336.n14 4.501
R6793 a_1416_13336.n15 a_1416_13336.n9 4.501
R6794 a_1416_13336.n16 a_1416_13336.n3 4.494
R6795 a_1416_13336.n18 a_1416_13336.t0 1.259
R6796 a_1416_13336.n12 a_1416_13336.n11 0.536
R6797 a_1416_13336.n18 a_1416_13336.n17 0.415
R6798 a_1416_13336.n14 a_1416_13336.n13 0.151
R6799 a_1416_13336.n7 a_1416_13336.n5 0.028
R6800 a_1416_13336.n3 a_1416_13336.n2 0.025
R6801 a_1416_13336.n17 a_1416_13336.n16 0.021
R6802 a_1416_13336.n9 a_1416_13336.n7 0.012
R6803 a_1416_13336.n16 a_1416_13336.n15 0.006
R6804 a_20456_4262.n26 a_20456_4262.t1 10.181
R6805 a_20456_4262.n18 a_20456_4262.t2 10.181
R6806 a_20456_4262.t0 a_20456_4262.n39 9.68
R6807 a_20456_4262.n3 a_20456_4262.n2 9.302
R6808 a_20456_4262.n13 a_20456_4262.n12 9.302
R6809 a_20456_4262.n32 a_20456_4262.n31 9.3
R6810 a_20456_4262.n34 a_20456_4262.n33 9.3
R6811 a_20456_4262.n7 a_20456_4262.n6 9.3
R6812 a_20456_4262.n5 a_20456_4262.n4 9.3
R6813 a_20456_4262.n36 a_20456_4262.n35 9
R6814 a_20456_4262.n9 a_20456_4262.n8 9
R6815 a_20456_4262.n27 a_20456_4262.n25 7.729
R6816 a_20456_4262.n19 a_20456_4262.n17 7.729
R6817 a_20456_4262.n27 a_20456_4262.n26 6.296
R6818 a_20456_4262.n19 a_20456_4262.n18 6.296
R6819 a_20456_4262.n30 a_20456_4262.n3 4.508
R6820 a_20456_4262.n14 a_20456_4262.n13 4.508
R6821 a_20456_4262.n37 a_20456_4262.n36 4.496
R6822 a_20456_4262.n21 a_20456_4262.n20 4.496
R6823 a_20456_4262.n29 a_20456_4262.n28 4.495
R6824 a_20456_4262.n10 a_20456_4262.n9 4.495
R6825 a_20456_4262.n14 a_20456_4262.n11 4.494
R6826 a_20456_4262.n30 a_20456_4262.n1 4.494
R6827 a_20456_4262.n39 a_20456_4262.t3 1.087
R6828 a_20456_4262.n25 a_20456_4262.n24 0.536
R6829 a_20456_4262.n17 a_20456_4262.n16 0.536
R6830 a_20456_4262.n39 a_20456_4262.n38 0.255
R6831 a_20456_4262.n28 a_20456_4262.n27 0.151
R6832 a_20456_4262.n20 a_20456_4262.n19 0.151
R6833 a_20456_4262.n23 a_20456_4262.n22 0.125
R6834 a_20456_4262.n34 a_20456_4262.n32 0.028
R6835 a_20456_4262.n7 a_20456_4262.n5 0.028
R6836 a_20456_4262.n1 a_20456_4262.n0 0.025
R6837 a_20456_4262.n20 a_20456_4262.n15 0.024
R6838 a_20456_4262.n36 a_20456_4262.n34 0.012
R6839 a_20456_4262.n9 a_20456_4262.n7 0.012
R6840 a_20456_4262.n29 a_20456_4262.n23 0.011
R6841 a_20456_4262.n30 a_20456_4262.n29 0.011
R6842 a_20456_4262.n14 a_20456_4262.n10 0.011
R6843 a_20456_4262.n38 a_20456_4262.n37 0.01
R6844 a_20456_4262.n22 a_20456_4262.n21 0.01
R6845 a_20456_4262.n21 a_20456_4262.n14 0.01
R6846 a_20456_4262.n37 a_20456_4262.n30 0.01
R6847 bit4.n0 bit4.t8 552.693
R6848 bit4.n3 bit4.t13 300.446
R6849 bit4.n1 bit4.t10 300.446
R6850 bit4.n10 bit4.t16 300.446
R6851 bit4.n8 bit4.t23 300.446
R6852 bit4.n18 bit4.t32 300.446
R6853 bit4.n16 bit4.t27 300.446
R6854 bit4.n26 bit4.t2 300.446
R6855 bit4.n24 bit4.t11 300.446
R6856 bit4.n34 bit4.t28 300.446
R6857 bit4.n32 bit4.t26 300.446
R6858 bit4.n42 bit4.t4 300.446
R6859 bit4.n40 bit4.t12 300.446
R6860 bit4.n50 bit4.t18 300.446
R6861 bit4.n48 bit4.t14 300.446
R6862 bit4.n60 bit4.t21 300.446
R6863 bit4.n58 bit4.t30 300.446
R6864 bit4.n67 bit4.t0 300.446
R6865 bit4.n65 bit4.t7 300.446
R6866 bit4.n75 bit4.t33 300.446
R6867 bit4.n73 bit4.t29 300.446
R6868 bit4.n83 bit4.t17 300.446
R6869 bit4.n81 bit4.t24 300.446
R6870 bit4.n91 bit4.t6 300.446
R6871 bit4.n89 bit4.t3 300.446
R6872 bit4.n99 bit4.t15 300.446
R6873 bit4.n97 bit4.t22 300.446
R6874 bit4.n107 bit4.t9 300.446
R6875 bit4.n105 bit4.t5 300.446
R6876 bit4.n115 bit4.t31 300.446
R6877 bit4.n113 bit4.t1 300.446
R6878 bit4.n123 bit4.t25 300.446
R6879 bit4.n121 bit4.t20 300.446
R6880 bit4.n0 bit4.t19 279.56
R6881 bit4.n64 bit4.n0 119.784
R6882 bit4.n59 bit4.n58 27.537
R6883 bit4.n6 bit4.n3 27.536
R6884 bit4.n13 bit4.n10 27.536
R6885 bit4.n21 bit4.n18 27.536
R6886 bit4.n29 bit4.n26 27.536
R6887 bit4.n37 bit4.n34 27.536
R6888 bit4.n45 bit4.n42 27.536
R6889 bit4.n53 bit4.n50 27.536
R6890 bit4.n70 bit4.n67 27.536
R6891 bit4.n78 bit4.n75 27.536
R6892 bit4.n86 bit4.n83 27.536
R6893 bit4.n94 bit4.n91 27.536
R6894 bit4.n102 bit4.n99 27.536
R6895 bit4.n110 bit4.n107 27.536
R6896 bit4.n118 bit4.n115 27.536
R6897 bit4.n126 bit4.n123 27.536
R6898 bit4.n2 bit4.n1 24.127
R6899 bit4.n9 bit4.n8 24.127
R6900 bit4.n17 bit4.n16 24.127
R6901 bit4.n25 bit4.n24 24.127
R6902 bit4.n33 bit4.n32 24.127
R6903 bit4.n41 bit4.n40 24.127
R6904 bit4.n49 bit4.n48 24.127
R6905 bit4.n61 bit4.n60 24.127
R6906 bit4.n66 bit4.n65 24.127
R6907 bit4.n74 bit4.n73 24.127
R6908 bit4.n82 bit4.n81 24.127
R6909 bit4.n90 bit4.n89 24.127
R6910 bit4.n98 bit4.n97 24.127
R6911 bit4.n106 bit4.n105 24.127
R6912 bit4.n114 bit4.n113 24.127
R6913 bit4.n122 bit4.n121 24.127
R6914 bit4.n5 bit4.n4 8.764
R6915 bit4.n12 bit4.n11 8.764
R6916 bit4.n20 bit4.n19 8.764
R6917 bit4.n28 bit4.n27 8.764
R6918 bit4.n36 bit4.n35 8.764
R6919 bit4.n44 bit4.n43 8.764
R6920 bit4.n52 bit4.n51 8.764
R6921 bit4.n57 bit4.n56 8.764
R6922 bit4.n69 bit4.n68 8.764
R6923 bit4.n77 bit4.n76 8.764
R6924 bit4.n85 bit4.n84 8.764
R6925 bit4.n93 bit4.n92 8.764
R6926 bit4.n101 bit4.n100 8.764
R6927 bit4.n109 bit4.n108 8.764
R6928 bit4.n117 bit4.n116 8.764
R6929 bit4.n125 bit4.n124 8.764
R6930 bit4.n15 bit4.n7 5.287
R6931 bit4.n23 bit4.n15 4.958
R6932 bit4.n31 bit4.n23 4.958
R6933 bit4.n39 bit4.n31 4.958
R6934 bit4.n47 bit4.n39 4.958
R6935 bit4.n55 bit4.n47 4.958
R6936 bit4.n63 bit4.n55 4.958
R6937 bit4.n80 bit4.n72 4.958
R6938 bit4.n88 bit4.n80 4.958
R6939 bit4.n96 bit4.n88 4.958
R6940 bit4.n104 bit4.n96 4.958
R6941 bit4.n112 bit4.n104 4.958
R6942 bit4.n120 bit4.n112 4.958
R6943 bit4.n128 bit4.n120 4.958
R6944 bit4.n7 bit4.n2 4.662
R6945 bit4.n14 bit4.n9 4.662
R6946 bit4.n22 bit4.n17 4.662
R6947 bit4.n30 bit4.n25 4.662
R6948 bit4.n38 bit4.n33 4.662
R6949 bit4.n46 bit4.n41 4.662
R6950 bit4.n54 bit4.n49 4.662
R6951 bit4.n71 bit4.n66 4.662
R6952 bit4.n79 bit4.n74 4.662
R6953 bit4.n87 bit4.n82 4.662
R6954 bit4.n95 bit4.n90 4.662
R6955 bit4.n103 bit4.n98 4.662
R6956 bit4.n111 bit4.n106 4.662
R6957 bit4.n119 bit4.n114 4.662
R6958 bit4.n127 bit4.n122 4.662
R6959 bit4.n62 bit4.n61 4.661
R6960 bit4.n64 bit4.n63 4.576
R6961 bit4.n6 bit4.n5 3.401
R6962 bit4.n13 bit4.n12 3.401
R6963 bit4.n21 bit4.n20 3.401
R6964 bit4.n29 bit4.n28 3.401
R6965 bit4.n37 bit4.n36 3.401
R6966 bit4.n45 bit4.n44 3.401
R6967 bit4.n53 bit4.n52 3.401
R6968 bit4.n70 bit4.n69 3.401
R6969 bit4.n78 bit4.n77 3.401
R6970 bit4.n86 bit4.n85 3.401
R6971 bit4.n94 bit4.n93 3.401
R6972 bit4.n102 bit4.n101 3.401
R6973 bit4.n110 bit4.n109 3.401
R6974 bit4.n118 bit4.n117 3.401
R6975 bit4.n126 bit4.n125 3.401
R6976 bit4.n59 bit4.n57 3.401
R6977 bit4.n72 bit4.n64 3.02
R6978 bit4 bit4.n128 2.986
R6979 bit4.n62 bit4.n59 0.626
R6980 bit4.n7 bit4.n6 0.626
R6981 bit4.n14 bit4.n13 0.626
R6982 bit4.n22 bit4.n21 0.626
R6983 bit4.n30 bit4.n29 0.626
R6984 bit4.n38 bit4.n37 0.626
R6985 bit4.n46 bit4.n45 0.626
R6986 bit4.n54 bit4.n53 0.626
R6987 bit4.n71 bit4.n70 0.626
R6988 bit4.n79 bit4.n78 0.626
R6989 bit4.n87 bit4.n86 0.626
R6990 bit4.n95 bit4.n94 0.626
R6991 bit4.n103 bit4.n102 0.626
R6992 bit4.n111 bit4.n110 0.626
R6993 bit4.n119 bit4.n118 0.626
R6994 bit4.n127 bit4.n126 0.626
R6995 bit4.n15 bit4.n14 0.329
R6996 bit4.n23 bit4.n22 0.329
R6997 bit4.n31 bit4.n30 0.329
R6998 bit4.n39 bit4.n38 0.329
R6999 bit4.n47 bit4.n46 0.329
R7000 bit4.n55 bit4.n54 0.329
R7001 bit4.n63 bit4.n62 0.329
R7002 bit4.n72 bit4.n71 0.329
R7003 bit4.n80 bit4.n79 0.329
R7004 bit4.n88 bit4.n87 0.329
R7005 bit4.n96 bit4.n95 0.329
R7006 bit4.n104 bit4.n103 0.329
R7007 bit4.n112 bit4.n111 0.329
R7008 bit4.n120 bit4.n119 0.329
R7009 bit4.n128 bit4.n127 0.329
R7010 a_1416_7846.n10 a_1416_7846.t3 10.181
R7011 a_1416_7846.n10 a_1416_7846.t2 10.181
R7012 a_1416_7846.t0 a_1416_7846.n18 9.68
R7013 a_1416_7846.n1 a_1416_7846.n0 9.302
R7014 a_1416_7846.n7 a_1416_7846.n6 9.3
R7015 a_1416_7846.n5 a_1416_7846.n4 9.3
R7016 a_1416_7846.n9 a_1416_7846.n8 9
R7017 a_1416_7846.n13 a_1416_7846.n12 7.729
R7018 a_1416_7846.n13 a_1416_7846.n10 6.296
R7019 a_1416_7846.n16 a_1416_7846.n1 4.508
R7020 a_1416_7846.n15 a_1416_7846.n14 4.501
R7021 a_1416_7846.n15 a_1416_7846.n9 4.501
R7022 a_1416_7846.n16 a_1416_7846.n3 4.494
R7023 a_1416_7846.n18 a_1416_7846.t1 1.259
R7024 a_1416_7846.n12 a_1416_7846.n11 0.536
R7025 a_1416_7846.n18 a_1416_7846.n17 0.415
R7026 a_1416_7846.n14 a_1416_7846.n13 0.151
R7027 a_1416_7846.n7 a_1416_7846.n5 0.028
R7028 a_1416_7846.n3 a_1416_7846.n2 0.025
R7029 a_1416_7846.n17 a_1416_7846.n16 0.021
R7030 a_1416_7846.n9 a_1416_7846.n7 0.012
R7031 a_1416_7846.n16 a_1416_7846.n15 0.006
R7032 a_1706_7922.n26 a_1706_7922.t3 10.181
R7033 a_1706_7922.n18 a_1706_7922.t2 10.181
R7034 a_1706_7922.t0 a_1706_7922.n39 9.68
R7035 a_1706_7922.n3 a_1706_7922.n2 9.302
R7036 a_1706_7922.n13 a_1706_7922.n12 9.302
R7037 a_1706_7922.n32 a_1706_7922.n31 9.3
R7038 a_1706_7922.n34 a_1706_7922.n33 9.3
R7039 a_1706_7922.n7 a_1706_7922.n6 9.3
R7040 a_1706_7922.n5 a_1706_7922.n4 9.3
R7041 a_1706_7922.n36 a_1706_7922.n35 9
R7042 a_1706_7922.n9 a_1706_7922.n8 9
R7043 a_1706_7922.n27 a_1706_7922.n25 7.729
R7044 a_1706_7922.n19 a_1706_7922.n17 7.729
R7045 a_1706_7922.n27 a_1706_7922.n26 6.296
R7046 a_1706_7922.n19 a_1706_7922.n18 6.296
R7047 a_1706_7922.n30 a_1706_7922.n3 4.508
R7048 a_1706_7922.n14 a_1706_7922.n13 4.508
R7049 a_1706_7922.n37 a_1706_7922.n36 4.496
R7050 a_1706_7922.n21 a_1706_7922.n20 4.496
R7051 a_1706_7922.n29 a_1706_7922.n28 4.495
R7052 a_1706_7922.n10 a_1706_7922.n9 4.495
R7053 a_1706_7922.n14 a_1706_7922.n11 4.494
R7054 a_1706_7922.n30 a_1706_7922.n1 4.494
R7055 a_1706_7922.n39 a_1706_7922.t1 1.087
R7056 a_1706_7922.n25 a_1706_7922.n24 0.536
R7057 a_1706_7922.n17 a_1706_7922.n16 0.536
R7058 a_1706_7922.n39 a_1706_7922.n38 0.255
R7059 a_1706_7922.n28 a_1706_7922.n27 0.151
R7060 a_1706_7922.n20 a_1706_7922.n19 0.151
R7061 a_1706_7922.n23 a_1706_7922.n22 0.125
R7062 a_1706_7922.n34 a_1706_7922.n32 0.028
R7063 a_1706_7922.n7 a_1706_7922.n5 0.028
R7064 a_1706_7922.n1 a_1706_7922.n0 0.025
R7065 a_1706_7922.n20 a_1706_7922.n15 0.024
R7066 a_1706_7922.n36 a_1706_7922.n34 0.012
R7067 a_1706_7922.n9 a_1706_7922.n7 0.012
R7068 a_1706_7922.n29 a_1706_7922.n23 0.011
R7069 a_1706_7922.n30 a_1706_7922.n29 0.011
R7070 a_1706_7922.n14 a_1706_7922.n10 0.011
R7071 a_1706_7922.n38 a_1706_7922.n37 0.01
R7072 a_1706_7922.n22 a_1706_7922.n21 0.01
R7073 a_1706_7922.n21 a_1706_7922.n14 0.01
R7074 a_1706_7922.n37 a_1706_7922.n30 0.01
R7075 a_24206_7922.n26 a_24206_7922.t2 10.181
R7076 a_24206_7922.n18 a_24206_7922.t3 10.181
R7077 a_24206_7922.t0 a_24206_7922.n39 9.68
R7078 a_24206_7922.n3 a_24206_7922.n2 9.302
R7079 a_24206_7922.n13 a_24206_7922.n12 9.302
R7080 a_24206_7922.n32 a_24206_7922.n31 9.3
R7081 a_24206_7922.n34 a_24206_7922.n33 9.3
R7082 a_24206_7922.n7 a_24206_7922.n6 9.3
R7083 a_24206_7922.n5 a_24206_7922.n4 9.3
R7084 a_24206_7922.n36 a_24206_7922.n35 9
R7085 a_24206_7922.n9 a_24206_7922.n8 9
R7086 a_24206_7922.n27 a_24206_7922.n25 7.729
R7087 a_24206_7922.n19 a_24206_7922.n17 7.729
R7088 a_24206_7922.n27 a_24206_7922.n26 6.296
R7089 a_24206_7922.n19 a_24206_7922.n18 6.296
R7090 a_24206_7922.n30 a_24206_7922.n3 4.508
R7091 a_24206_7922.n14 a_24206_7922.n13 4.508
R7092 a_24206_7922.n37 a_24206_7922.n36 4.496
R7093 a_24206_7922.n21 a_24206_7922.n20 4.496
R7094 a_24206_7922.n29 a_24206_7922.n28 4.495
R7095 a_24206_7922.n10 a_24206_7922.n9 4.495
R7096 a_24206_7922.n14 a_24206_7922.n11 4.494
R7097 a_24206_7922.n30 a_24206_7922.n1 4.494
R7098 a_24206_7922.n39 a_24206_7922.t1 1.087
R7099 a_24206_7922.n25 a_24206_7922.n24 0.536
R7100 a_24206_7922.n17 a_24206_7922.n16 0.536
R7101 a_24206_7922.n39 a_24206_7922.n38 0.255
R7102 a_24206_7922.n28 a_24206_7922.n27 0.151
R7103 a_24206_7922.n20 a_24206_7922.n19 0.151
R7104 a_24206_7922.n23 a_24206_7922.n22 0.125
R7105 a_24206_7922.n34 a_24206_7922.n32 0.028
R7106 a_24206_7922.n7 a_24206_7922.n5 0.028
R7107 a_24206_7922.n1 a_24206_7922.n0 0.025
R7108 a_24206_7922.n20 a_24206_7922.n15 0.024
R7109 a_24206_7922.n36 a_24206_7922.n34 0.012
R7110 a_24206_7922.n9 a_24206_7922.n7 0.012
R7111 a_24206_7922.n29 a_24206_7922.n23 0.011
R7112 a_24206_7922.n30 a_24206_7922.n29 0.011
R7113 a_24206_7922.n14 a_24206_7922.n10 0.011
R7114 a_24206_7922.n38 a_24206_7922.n37 0.01
R7115 a_24206_7922.n22 a_24206_7922.n21 0.01
R7116 a_24206_7922.n21 a_24206_7922.n14 0.01
R7117 a_24206_7922.n37 a_24206_7922.n30 0.01
R7118 a_23916_7846.n10 a_23916_7846.t2 10.181
R7119 a_23916_7846.n10 a_23916_7846.t3 10.181
R7120 a_23916_7846.t1 a_23916_7846.n18 9.68
R7121 a_23916_7846.n1 a_23916_7846.n0 9.302
R7122 a_23916_7846.n7 a_23916_7846.n6 9.3
R7123 a_23916_7846.n5 a_23916_7846.n4 9.3
R7124 a_23916_7846.n9 a_23916_7846.n8 9
R7125 a_23916_7846.n13 a_23916_7846.n12 7.729
R7126 a_23916_7846.n13 a_23916_7846.n10 6.296
R7127 a_23916_7846.n16 a_23916_7846.n1 4.508
R7128 a_23916_7846.n15 a_23916_7846.n14 4.501
R7129 a_23916_7846.n15 a_23916_7846.n9 4.501
R7130 a_23916_7846.n16 a_23916_7846.n3 4.494
R7131 a_23916_7846.n18 a_23916_7846.t0 1.259
R7132 a_23916_7846.n12 a_23916_7846.n11 0.536
R7133 a_23916_7846.n18 a_23916_7846.n17 0.415
R7134 a_23916_7846.n14 a_23916_7846.n13 0.151
R7135 a_23916_7846.n7 a_23916_7846.n5 0.028
R7136 a_23916_7846.n3 a_23916_7846.n2 0.025
R7137 a_23916_7846.n17 a_23916_7846.n16 0.021
R7138 a_23916_7846.n9 a_23916_7846.n7 0.012
R7139 a_23916_7846.n16 a_23916_7846.n15 0.006
R7140 bit3.n0 bit3.t13 552.693
R7141 bit3.n5 bit3.t11 300.446
R7142 bit3.n3 bit3.t0 300.446
R7143 bit3.n11 bit3.t9 300.446
R7144 bit3.n9 bit3.t5 300.446
R7145 bit3.n19 bit3.t17 300.446
R7146 bit3.n17 bit3.t4 300.446
R7147 bit3.n27 bit3.t1 300.446
R7148 bit3.n25 bit3.t12 300.446
R7149 bit3.n35 bit3.t7 300.446
R7150 bit3.n33 bit3.t15 300.446
R7151 bit3.n43 bit3.t14 300.446
R7152 bit3.n41 bit3.t10 300.446
R7153 bit3.n51 bit3.t3 300.446
R7154 bit3.n49 bit3.t8 300.446
R7155 bit3.n59 bit3.t2 300.446
R7156 bit3.n57 bit3.t16 300.446
R7157 bit3.n0 bit3.t6 279.56
R7158 bit3.n8 bit3.n0 122.804
R7159 bit3.n4 bit3.n3 27.537
R7160 bit3.n14 bit3.n11 27.536
R7161 bit3.n22 bit3.n19 27.536
R7162 bit3.n30 bit3.n27 27.536
R7163 bit3.n38 bit3.n35 27.536
R7164 bit3.n46 bit3.n43 27.536
R7165 bit3.n54 bit3.n51 27.536
R7166 bit3.n62 bit3.n59 27.536
R7167 bit3.n6 bit3.n5 24.127
R7168 bit3.n10 bit3.n9 24.127
R7169 bit3.n18 bit3.n17 24.127
R7170 bit3.n26 bit3.n25 24.127
R7171 bit3.n34 bit3.n33 24.127
R7172 bit3.n42 bit3.n41 24.127
R7173 bit3.n50 bit3.n49 24.127
R7174 bit3.n58 bit3.n57 24.127
R7175 bit3.n2 bit3.n1 8.764
R7176 bit3.n13 bit3.n12 8.764
R7177 bit3.n21 bit3.n20 8.764
R7178 bit3.n29 bit3.n28 8.764
R7179 bit3.n37 bit3.n36 8.764
R7180 bit3.n45 bit3.n44 8.764
R7181 bit3.n53 bit3.n52 8.764
R7182 bit3.n61 bit3.n60 8.764
R7183 bit3.n16 bit3.n8 4.958
R7184 bit3.n24 bit3.n16 4.958
R7185 bit3.n32 bit3.n24 4.958
R7186 bit3.n40 bit3.n32 4.958
R7187 bit3.n48 bit3.n40 4.958
R7188 bit3.n56 bit3.n48 4.958
R7189 bit3.n64 bit3.n56 4.958
R7190 bit3.n15 bit3.n10 4.662
R7191 bit3.n23 bit3.n18 4.662
R7192 bit3.n31 bit3.n26 4.662
R7193 bit3.n39 bit3.n34 4.662
R7194 bit3.n47 bit3.n42 4.662
R7195 bit3.n55 bit3.n50 4.662
R7196 bit3.n63 bit3.n58 4.662
R7197 bit3.n7 bit3.n6 4.661
R7198 bit3.n14 bit3.n13 3.401
R7199 bit3.n22 bit3.n21 3.401
R7200 bit3.n30 bit3.n29 3.401
R7201 bit3.n38 bit3.n37 3.401
R7202 bit3.n46 bit3.n45 3.401
R7203 bit3.n54 bit3.n53 3.401
R7204 bit3.n62 bit3.n61 3.401
R7205 bit3.n4 bit3.n2 3.401
R7206 bit3 bit3.n64 2.986
R7207 bit3.n7 bit3.n4 0.626
R7208 bit3.n15 bit3.n14 0.626
R7209 bit3.n23 bit3.n22 0.626
R7210 bit3.n31 bit3.n30 0.626
R7211 bit3.n39 bit3.n38 0.626
R7212 bit3.n47 bit3.n46 0.626
R7213 bit3.n55 bit3.n54 0.626
R7214 bit3.n63 bit3.n62 0.626
R7215 bit3.n8 bit3.n7 0.329
R7216 bit3.n16 bit3.n15 0.329
R7217 bit3.n24 bit3.n23 0.329
R7218 bit3.n32 bit3.n31 0.329
R7219 bit3.n40 bit3.n39 0.329
R7220 bit3.n48 bit3.n47 0.329
R7221 bit3.n56 bit3.n55 0.329
R7222 bit3.n64 bit3.n63 0.329
R7223 a_1706_11582.n26 a_1706_11582.t0 10.181
R7224 a_1706_11582.n18 a_1706_11582.t1 10.181
R7225 a_1706_11582.t2 a_1706_11582.n39 9.68
R7226 a_1706_11582.n3 a_1706_11582.n2 9.302
R7227 a_1706_11582.n13 a_1706_11582.n12 9.302
R7228 a_1706_11582.n32 a_1706_11582.n31 9.3
R7229 a_1706_11582.n34 a_1706_11582.n33 9.3
R7230 a_1706_11582.n7 a_1706_11582.n6 9.3
R7231 a_1706_11582.n5 a_1706_11582.n4 9.3
R7232 a_1706_11582.n36 a_1706_11582.n35 9
R7233 a_1706_11582.n9 a_1706_11582.n8 9
R7234 a_1706_11582.n27 a_1706_11582.n25 7.729
R7235 a_1706_11582.n19 a_1706_11582.n17 7.729
R7236 a_1706_11582.n27 a_1706_11582.n26 6.296
R7237 a_1706_11582.n19 a_1706_11582.n18 6.296
R7238 a_1706_11582.n30 a_1706_11582.n3 4.508
R7239 a_1706_11582.n14 a_1706_11582.n13 4.508
R7240 a_1706_11582.n37 a_1706_11582.n36 4.496
R7241 a_1706_11582.n21 a_1706_11582.n20 4.496
R7242 a_1706_11582.n29 a_1706_11582.n28 4.495
R7243 a_1706_11582.n10 a_1706_11582.n9 4.495
R7244 a_1706_11582.n14 a_1706_11582.n11 4.494
R7245 a_1706_11582.n30 a_1706_11582.n1 4.494
R7246 a_1706_11582.n39 a_1706_11582.t3 1.087
R7247 a_1706_11582.n25 a_1706_11582.n24 0.536
R7248 a_1706_11582.n17 a_1706_11582.n16 0.536
R7249 a_1706_11582.n39 a_1706_11582.n38 0.255
R7250 a_1706_11582.n28 a_1706_11582.n27 0.151
R7251 a_1706_11582.n20 a_1706_11582.n19 0.151
R7252 a_1706_11582.n23 a_1706_11582.n22 0.125
R7253 a_1706_11582.n34 a_1706_11582.n32 0.028
R7254 a_1706_11582.n7 a_1706_11582.n5 0.028
R7255 a_1706_11582.n1 a_1706_11582.n0 0.025
R7256 a_1706_11582.n20 a_1706_11582.n15 0.024
R7257 a_1706_11582.n36 a_1706_11582.n34 0.012
R7258 a_1706_11582.n9 a_1706_11582.n7 0.012
R7259 a_1706_11582.n29 a_1706_11582.n23 0.011
R7260 a_1706_11582.n30 a_1706_11582.n29 0.011
R7261 a_1706_11582.n14 a_1706_11582.n10 0.011
R7262 a_1706_11582.n38 a_1706_11582.n37 0.01
R7263 a_1706_11582.n22 a_1706_11582.n21 0.01
R7264 a_1706_11582.n21 a_1706_11582.n14 0.01
R7265 a_1706_11582.n37 a_1706_11582.n30 0.01
R7266 a_1416_11506.n10 a_1416_11506.t2 10.181
R7267 a_1416_11506.n10 a_1416_11506.t3 10.181
R7268 a_1416_11506.t0 a_1416_11506.n18 9.68
R7269 a_1416_11506.n1 a_1416_11506.n0 9.302
R7270 a_1416_11506.n7 a_1416_11506.n6 9.3
R7271 a_1416_11506.n5 a_1416_11506.n4 9.3
R7272 a_1416_11506.n9 a_1416_11506.n8 9
R7273 a_1416_11506.n13 a_1416_11506.n12 7.729
R7274 a_1416_11506.n13 a_1416_11506.n10 6.296
R7275 a_1416_11506.n16 a_1416_11506.n1 4.508
R7276 a_1416_11506.n15 a_1416_11506.n14 4.501
R7277 a_1416_11506.n15 a_1416_11506.n9 4.501
R7278 a_1416_11506.n16 a_1416_11506.n3 4.494
R7279 a_1416_11506.n18 a_1416_11506.t1 1.259
R7280 a_1416_11506.n12 a_1416_11506.n11 0.536
R7281 a_1416_11506.n18 a_1416_11506.n17 0.415
R7282 a_1416_11506.n14 a_1416_11506.n13 0.151
R7283 a_1416_11506.n7 a_1416_11506.n5 0.028
R7284 a_1416_11506.n3 a_1416_11506.n2 0.025
R7285 a_1416_11506.n17 a_1416_11506.n16 0.021
R7286 a_1416_11506.n9 a_1416_11506.n7 0.012
R7287 a_1416_11506.n16 a_1416_11506.n15 0.006
R7288 a_23916_526.n10 a_23916_526.t3 10.181
R7289 a_23916_526.n10 a_23916_526.t2 10.181
R7290 a_23916_526.t1 a_23916_526.n18 9.68
R7291 a_23916_526.n1 a_23916_526.n0 9.302
R7292 a_23916_526.n7 a_23916_526.n6 9.3
R7293 a_23916_526.n5 a_23916_526.n4 9.3
R7294 a_23916_526.n9 a_23916_526.n8 9
R7295 a_23916_526.n13 a_23916_526.n12 7.729
R7296 a_23916_526.n13 a_23916_526.n10 6.296
R7297 a_23916_526.n16 a_23916_526.n1 4.508
R7298 a_23916_526.n15 a_23916_526.n14 4.501
R7299 a_23916_526.n15 a_23916_526.n9 4.501
R7300 a_23916_526.n16 a_23916_526.n3 4.494
R7301 a_23916_526.n18 a_23916_526.t0 1.259
R7302 a_23916_526.n12 a_23916_526.n11 0.536
R7303 a_23916_526.n18 a_23916_526.n17 0.415
R7304 a_23916_526.n14 a_23916_526.n13 0.151
R7305 a_23916_526.n7 a_23916_526.n5 0.028
R7306 a_23916_526.n3 a_23916_526.n2 0.025
R7307 a_23916_526.n17 a_23916_526.n16 0.021
R7308 a_23916_526.n9 a_23916_526.n7 0.012
R7309 a_23916_526.n16 a_23916_526.n15 0.006
R7310 a_5456_15242.n26 a_5456_15242.t1 10.181
R7311 a_5456_15242.n18 a_5456_15242.t0 10.181
R7312 a_5456_15242.t2 a_5456_15242.n39 9.68
R7313 a_5456_15242.n3 a_5456_15242.n2 9.302
R7314 a_5456_15242.n13 a_5456_15242.n12 9.302
R7315 a_5456_15242.n32 a_5456_15242.n31 9.3
R7316 a_5456_15242.n34 a_5456_15242.n33 9.3
R7317 a_5456_15242.n7 a_5456_15242.n6 9.3
R7318 a_5456_15242.n5 a_5456_15242.n4 9.3
R7319 a_5456_15242.n36 a_5456_15242.n35 9
R7320 a_5456_15242.n9 a_5456_15242.n8 9
R7321 a_5456_15242.n27 a_5456_15242.n25 7.729
R7322 a_5456_15242.n19 a_5456_15242.n17 7.729
R7323 a_5456_15242.n27 a_5456_15242.n26 6.296
R7324 a_5456_15242.n19 a_5456_15242.n18 6.296
R7325 a_5456_15242.n30 a_5456_15242.n3 4.508
R7326 a_5456_15242.n14 a_5456_15242.n13 4.508
R7327 a_5456_15242.n37 a_5456_15242.n36 4.496
R7328 a_5456_15242.n21 a_5456_15242.n20 4.496
R7329 a_5456_15242.n29 a_5456_15242.n28 4.495
R7330 a_5456_15242.n10 a_5456_15242.n9 4.495
R7331 a_5456_15242.n14 a_5456_15242.n11 4.494
R7332 a_5456_15242.n30 a_5456_15242.n1 4.494
R7333 a_5456_15242.n39 a_5456_15242.t3 1.087
R7334 a_5456_15242.n25 a_5456_15242.n24 0.536
R7335 a_5456_15242.n17 a_5456_15242.n16 0.536
R7336 a_5456_15242.n39 a_5456_15242.n38 0.255
R7337 a_5456_15242.n28 a_5456_15242.n27 0.151
R7338 a_5456_15242.n20 a_5456_15242.n19 0.151
R7339 a_5456_15242.n23 a_5456_15242.n22 0.125
R7340 a_5456_15242.n34 a_5456_15242.n32 0.028
R7341 a_5456_15242.n7 a_5456_15242.n5 0.028
R7342 a_5456_15242.n1 a_5456_15242.n0 0.025
R7343 a_5456_15242.n20 a_5456_15242.n15 0.024
R7344 a_5456_15242.n36 a_5456_15242.n34 0.012
R7345 a_5456_15242.n9 a_5456_15242.n7 0.012
R7346 a_5456_15242.n29 a_5456_15242.n23 0.011
R7347 a_5456_15242.n30 a_5456_15242.n29 0.011
R7348 a_5456_15242.n14 a_5456_15242.n10 0.011
R7349 a_5456_15242.n38 a_5456_15242.n37 0.01
R7350 a_5456_15242.n22 a_5456_15242.n21 0.01
R7351 a_5456_15242.n21 a_5456_15242.n14 0.01
R7352 a_5456_15242.n37 a_5456_15242.n30 0.01
R7353 a_n456_14646.t0 a_n456_14646.n3 139.026
R7354 a_n456_14646.n3 a_n456_14646.t1 85.389
R7355 a_n456_14646.n3 a_n456_14646.n2 55.674
R7356 a_n456_14646.n0 a_n456_14646.t5 10.163
R7357 a_n456_14646.n2 a_n456_14646.t4 9.587
R7358 a_n456_14646.n1 a_n456_14646.t2 9.587
R7359 a_n456_14646.n0 a_n456_14646.t3 9.587
R7360 a_n456_14646.n1 a_n456_14646.n0 2.353
R7361 a_n456_14646.n2 a_n456_14646.n1 0.576
R7362 bit1.n0 bit1.t1 552.693
R7363 bit1.n5 bit1.t5 300.446
R7364 bit1.n3 bit1.t0 300.446
R7365 bit1.n11 bit1.t4 300.446
R7366 bit1.n9 bit1.t2 300.446
R7367 bit1.n0 bit1.t3 279.56
R7368 bit1.n8 bit1.n0 122.804
R7369 bit1 bit1.n16 34.236
R7370 bit1.n4 bit1.n3 27.537
R7371 bit1.n14 bit1.n11 27.536
R7372 bit1.n6 bit1.n5 24.127
R7373 bit1.n10 bit1.n9 24.127
R7374 bit1.n2 bit1.n1 8.764
R7375 bit1.n13 bit1.n12 8.764
R7376 bit1.n16 bit1.n8 4.958
R7377 bit1.n15 bit1.n10 4.662
R7378 bit1.n7 bit1.n6 4.661
R7379 bit1.n14 bit1.n13 3.401
R7380 bit1.n4 bit1.n2 3.401
R7381 bit1.n7 bit1.n4 0.626
R7382 bit1.n15 bit1.n14 0.626
R7383 bit1.n8 bit1.n7 0.329
R7384 bit1.n16 bit1.n15 0.329
R7385 a_1416_15166.n10 a_1416_15166.t2 10.181
R7386 a_1416_15166.n10 a_1416_15166.t3 10.181
R7387 a_1416_15166.t0 a_1416_15166.n18 9.68
R7388 a_1416_15166.n1 a_1416_15166.n0 9.302
R7389 a_1416_15166.n7 a_1416_15166.n6 9.3
R7390 a_1416_15166.n5 a_1416_15166.n4 9.3
R7391 a_1416_15166.n9 a_1416_15166.n8 9
R7392 a_1416_15166.n13 a_1416_15166.n12 7.729
R7393 a_1416_15166.n13 a_1416_15166.n10 6.296
R7394 a_1416_15166.n16 a_1416_15166.n1 4.508
R7395 a_1416_15166.n15 a_1416_15166.n14 4.501
R7396 a_1416_15166.n15 a_1416_15166.n9 4.501
R7397 a_1416_15166.n16 a_1416_15166.n3 4.494
R7398 a_1416_15166.n18 a_1416_15166.t1 1.259
R7399 a_1416_15166.n12 a_1416_15166.n11 0.536
R7400 a_1416_15166.n18 a_1416_15166.n17 0.415
R7401 a_1416_15166.n14 a_1416_15166.n13 0.151
R7402 a_1416_15166.n7 a_1416_15166.n5 0.028
R7403 a_1416_15166.n3 a_1416_15166.n2 0.025
R7404 a_1416_15166.n17 a_1416_15166.n16 0.021
R7405 a_1416_15166.n9 a_1416_15166.n7 0.012
R7406 a_1416_15166.n16 a_1416_15166.n15 0.006
R7407 a_24206_11582.n26 a_24206_11582.t2 10.181
R7408 a_24206_11582.n18 a_24206_11582.t1 10.181
R7409 a_24206_11582.t0 a_24206_11582.n39 9.68
R7410 a_24206_11582.n3 a_24206_11582.n2 9.302
R7411 a_24206_11582.n13 a_24206_11582.n12 9.302
R7412 a_24206_11582.n32 a_24206_11582.n31 9.3
R7413 a_24206_11582.n34 a_24206_11582.n33 9.3
R7414 a_24206_11582.n7 a_24206_11582.n6 9.3
R7415 a_24206_11582.n5 a_24206_11582.n4 9.3
R7416 a_24206_11582.n36 a_24206_11582.n35 9
R7417 a_24206_11582.n9 a_24206_11582.n8 9
R7418 a_24206_11582.n27 a_24206_11582.n25 7.729
R7419 a_24206_11582.n19 a_24206_11582.n17 7.729
R7420 a_24206_11582.n27 a_24206_11582.n26 6.296
R7421 a_24206_11582.n19 a_24206_11582.n18 6.296
R7422 a_24206_11582.n30 a_24206_11582.n3 4.508
R7423 a_24206_11582.n14 a_24206_11582.n13 4.508
R7424 a_24206_11582.n37 a_24206_11582.n36 4.496
R7425 a_24206_11582.n21 a_24206_11582.n20 4.496
R7426 a_24206_11582.n29 a_24206_11582.n28 4.495
R7427 a_24206_11582.n10 a_24206_11582.n9 4.495
R7428 a_24206_11582.n14 a_24206_11582.n11 4.494
R7429 a_24206_11582.n30 a_24206_11582.n1 4.494
R7430 a_24206_11582.n39 a_24206_11582.t3 1.087
R7431 a_24206_11582.n25 a_24206_11582.n24 0.536
R7432 a_24206_11582.n17 a_24206_11582.n16 0.536
R7433 a_24206_11582.n39 a_24206_11582.n38 0.255
R7434 a_24206_11582.n28 a_24206_11582.n27 0.151
R7435 a_24206_11582.n20 a_24206_11582.n19 0.151
R7436 a_24206_11582.n23 a_24206_11582.n22 0.125
R7437 a_24206_11582.n34 a_24206_11582.n32 0.028
R7438 a_24206_11582.n7 a_24206_11582.n5 0.028
R7439 a_24206_11582.n1 a_24206_11582.n0 0.025
R7440 a_24206_11582.n20 a_24206_11582.n15 0.024
R7441 a_24206_11582.n36 a_24206_11582.n34 0.012
R7442 a_24206_11582.n9 a_24206_11582.n7 0.012
R7443 a_24206_11582.n29 a_24206_11582.n23 0.011
R7444 a_24206_11582.n30 a_24206_11582.n29 0.011
R7445 a_24206_11582.n14 a_24206_11582.n10 0.011
R7446 a_24206_11582.n38 a_24206_11582.n37 0.01
R7447 a_24206_11582.n22 a_24206_11582.n21 0.01
R7448 a_24206_11582.n21 a_24206_11582.n14 0.01
R7449 a_24206_11582.n37 a_24206_11582.n30 0.01
R7450 a_n456_10986.t7 a_n456_10986.n15 139.026
R7451 a_n456_10986.n15 a_n456_10986.t6 85.389
R7452 a_n456_10986.n15 a_n456_10986.n14 55.674
R7453 a_n456_10986.n0 a_n456_10986.t9 10.163
R7454 a_n456_10986.n14 a_n456_10986.t0 9.587
R7455 a_n456_10986.n13 a_n456_10986.t11 9.587
R7456 a_n456_10986.n12 a_n456_10986.t12 9.587
R7457 a_n456_10986.n11 a_n456_10986.t3 9.587
R7458 a_n456_10986.n10 a_n456_10986.t4 9.587
R7459 a_n456_10986.n9 a_n456_10986.t2 9.587
R7460 a_n456_10986.n8 a_n456_10986.t17 9.587
R7461 a_n456_10986.n7 a_n456_10986.t14 9.587
R7462 a_n456_10986.n6 a_n456_10986.t10 9.587
R7463 a_n456_10986.n5 a_n456_10986.t13 9.587
R7464 a_n456_10986.n4 a_n456_10986.t1 9.587
R7465 a_n456_10986.n3 a_n456_10986.t8 9.587
R7466 a_n456_10986.n2 a_n456_10986.t16 9.587
R7467 a_n456_10986.n1 a_n456_10986.t5 9.587
R7468 a_n456_10986.n0 a_n456_10986.t15 9.587
R7469 a_n456_10986.n1 a_n456_10986.n0 2.353
R7470 a_n456_10986.n3 a_n456_10986.n2 2.353
R7471 a_n456_10986.n5 a_n456_10986.n4 2.353
R7472 a_n456_10986.n7 a_n456_10986.n6 2.353
R7473 a_n456_10986.n9 a_n456_10986.n8 2.353
R7474 a_n456_10986.n11 a_n456_10986.n10 2.353
R7475 a_n456_10986.n13 a_n456_10986.n12 2.353
R7476 a_n456_10986.n2 a_n456_10986.n1 0.576
R7477 a_n456_10986.n4 a_n456_10986.n3 0.576
R7478 a_n456_10986.n6 a_n456_10986.n5 0.576
R7479 a_n456_10986.n8 a_n456_10986.n7 0.576
R7480 a_n456_10986.n10 a_n456_10986.n9 0.576
R7481 a_n456_10986.n12 a_n456_10986.n11 0.576
R7482 a_n456_10986.n14 a_n456_10986.n13 0.576
R7483 a_12666_11506.n10 a_12666_11506.t2 10.181
R7484 a_12666_11506.n10 a_12666_11506.t1 10.181
R7485 a_12666_11506.t3 a_12666_11506.n18 9.68
R7486 a_12666_11506.n1 a_12666_11506.n0 9.302
R7487 a_12666_11506.n7 a_12666_11506.n6 9.3
R7488 a_12666_11506.n5 a_12666_11506.n4 9.3
R7489 a_12666_11506.n9 a_12666_11506.n8 9
R7490 a_12666_11506.n13 a_12666_11506.n12 7.729
R7491 a_12666_11506.n13 a_12666_11506.n10 6.296
R7492 a_12666_11506.n16 a_12666_11506.n1 4.508
R7493 a_12666_11506.n15 a_12666_11506.n14 4.501
R7494 a_12666_11506.n15 a_12666_11506.n9 4.501
R7495 a_12666_11506.n16 a_12666_11506.n3 4.494
R7496 a_12666_11506.n18 a_12666_11506.t0 1.259
R7497 a_12666_11506.n12 a_12666_11506.n11 0.536
R7498 a_12666_11506.n18 a_12666_11506.n17 0.415
R7499 a_12666_11506.n14 a_12666_11506.n13 0.151
R7500 a_12666_11506.n7 a_12666_11506.n5 0.028
R7501 a_12666_11506.n3 a_12666_11506.n2 0.025
R7502 a_12666_11506.n17 a_12666_11506.n16 0.021
R7503 a_12666_11506.n9 a_12666_11506.n7 0.012
R7504 a_12666_11506.n16 a_12666_11506.n15 0.006
R7505 a_20456_9752.n26 a_20456_9752.t2 10.181
R7506 a_20456_9752.n18 a_20456_9752.t3 10.181
R7507 a_20456_9752.t0 a_20456_9752.n39 9.68
R7508 a_20456_9752.n3 a_20456_9752.n2 9.302
R7509 a_20456_9752.n13 a_20456_9752.n12 9.302
R7510 a_20456_9752.n32 a_20456_9752.n31 9.3
R7511 a_20456_9752.n34 a_20456_9752.n33 9.3
R7512 a_20456_9752.n7 a_20456_9752.n6 9.3
R7513 a_20456_9752.n5 a_20456_9752.n4 9.3
R7514 a_20456_9752.n36 a_20456_9752.n35 9
R7515 a_20456_9752.n9 a_20456_9752.n8 9
R7516 a_20456_9752.n27 a_20456_9752.n25 7.729
R7517 a_20456_9752.n19 a_20456_9752.n17 7.729
R7518 a_20456_9752.n27 a_20456_9752.n26 6.296
R7519 a_20456_9752.n19 a_20456_9752.n18 6.296
R7520 a_20456_9752.n30 a_20456_9752.n3 4.508
R7521 a_20456_9752.n14 a_20456_9752.n13 4.508
R7522 a_20456_9752.n37 a_20456_9752.n36 4.496
R7523 a_20456_9752.n21 a_20456_9752.n20 4.496
R7524 a_20456_9752.n29 a_20456_9752.n28 4.495
R7525 a_20456_9752.n10 a_20456_9752.n9 4.495
R7526 a_20456_9752.n14 a_20456_9752.n11 4.494
R7527 a_20456_9752.n30 a_20456_9752.n1 4.494
R7528 a_20456_9752.n39 a_20456_9752.t1 1.087
R7529 a_20456_9752.n25 a_20456_9752.n24 0.536
R7530 a_20456_9752.n17 a_20456_9752.n16 0.536
R7531 a_20456_9752.n39 a_20456_9752.n38 0.255
R7532 a_20456_9752.n28 a_20456_9752.n27 0.151
R7533 a_20456_9752.n20 a_20456_9752.n19 0.151
R7534 a_20456_9752.n23 a_20456_9752.n22 0.125
R7535 a_20456_9752.n34 a_20456_9752.n32 0.028
R7536 a_20456_9752.n7 a_20456_9752.n5 0.028
R7537 a_20456_9752.n1 a_20456_9752.n0 0.025
R7538 a_20456_9752.n20 a_20456_9752.n15 0.024
R7539 a_20456_9752.n36 a_20456_9752.n34 0.012
R7540 a_20456_9752.n9 a_20456_9752.n7 0.012
R7541 a_20456_9752.n29 a_20456_9752.n23 0.011
R7542 a_20456_9752.n30 a_20456_9752.n29 0.011
R7543 a_20456_9752.n14 a_20456_9752.n10 0.011
R7544 a_20456_9752.n38 a_20456_9752.n37 0.01
R7545 a_20456_9752.n22 a_20456_9752.n21 0.01
R7546 a_20456_9752.n21 a_20456_9752.n14 0.01
R7547 a_20456_9752.n37 a_20456_9752.n30 0.01
R7548 a_12666_13336.n10 a_12666_13336.t2 10.181
R7549 a_12666_13336.n10 a_12666_13336.t3 10.181
R7550 a_12666_13336.t0 a_12666_13336.n18 9.68
R7551 a_12666_13336.n1 a_12666_13336.n0 9.302
R7552 a_12666_13336.n7 a_12666_13336.n6 9.3
R7553 a_12666_13336.n5 a_12666_13336.n4 9.3
R7554 a_12666_13336.n9 a_12666_13336.n8 9
R7555 a_12666_13336.n13 a_12666_13336.n12 7.729
R7556 a_12666_13336.n13 a_12666_13336.n10 6.296
R7557 a_12666_13336.n16 a_12666_13336.n1 4.508
R7558 a_12666_13336.n15 a_12666_13336.n14 4.501
R7559 a_12666_13336.n15 a_12666_13336.n9 4.501
R7560 a_12666_13336.n16 a_12666_13336.n3 4.494
R7561 a_12666_13336.n18 a_12666_13336.t1 1.259
R7562 a_12666_13336.n12 a_12666_13336.n11 0.536
R7563 a_12666_13336.n18 a_12666_13336.n17 0.415
R7564 a_12666_13336.n14 a_12666_13336.n13 0.151
R7565 a_12666_13336.n7 a_12666_13336.n5 0.028
R7566 a_12666_13336.n3 a_12666_13336.n2 0.025
R7567 a_12666_13336.n17 a_12666_13336.n16 0.021
R7568 a_12666_13336.n9 a_12666_13336.n7 0.012
R7569 a_12666_13336.n16 a_12666_13336.n15 0.006
R7570 a_24206_4262.n26 a_24206_4262.t1 10.181
R7571 a_24206_4262.n18 a_24206_4262.t2 10.181
R7572 a_24206_4262.t0 a_24206_4262.n39 9.68
R7573 a_24206_4262.n3 a_24206_4262.n2 9.302
R7574 a_24206_4262.n13 a_24206_4262.n12 9.302
R7575 a_24206_4262.n32 a_24206_4262.n31 9.3
R7576 a_24206_4262.n34 a_24206_4262.n33 9.3
R7577 a_24206_4262.n7 a_24206_4262.n6 9.3
R7578 a_24206_4262.n5 a_24206_4262.n4 9.3
R7579 a_24206_4262.n36 a_24206_4262.n35 9
R7580 a_24206_4262.n9 a_24206_4262.n8 9
R7581 a_24206_4262.n27 a_24206_4262.n25 7.729
R7582 a_24206_4262.n19 a_24206_4262.n17 7.729
R7583 a_24206_4262.n27 a_24206_4262.n26 6.296
R7584 a_24206_4262.n19 a_24206_4262.n18 6.296
R7585 a_24206_4262.n30 a_24206_4262.n3 4.508
R7586 a_24206_4262.n14 a_24206_4262.n13 4.508
R7587 a_24206_4262.n37 a_24206_4262.n36 4.496
R7588 a_24206_4262.n21 a_24206_4262.n20 4.496
R7589 a_24206_4262.n29 a_24206_4262.n28 4.495
R7590 a_24206_4262.n10 a_24206_4262.n9 4.495
R7591 a_24206_4262.n14 a_24206_4262.n11 4.494
R7592 a_24206_4262.n30 a_24206_4262.n1 4.494
R7593 a_24206_4262.n39 a_24206_4262.t3 1.087
R7594 a_24206_4262.n25 a_24206_4262.n24 0.536
R7595 a_24206_4262.n17 a_24206_4262.n16 0.536
R7596 a_24206_4262.n39 a_24206_4262.n38 0.255
R7597 a_24206_4262.n28 a_24206_4262.n27 0.151
R7598 a_24206_4262.n20 a_24206_4262.n19 0.151
R7599 a_24206_4262.n23 a_24206_4262.n22 0.125
R7600 a_24206_4262.n34 a_24206_4262.n32 0.028
R7601 a_24206_4262.n7 a_24206_4262.n5 0.028
R7602 a_24206_4262.n1 a_24206_4262.n0 0.025
R7603 a_24206_4262.n20 a_24206_4262.n15 0.024
R7604 a_24206_4262.n36 a_24206_4262.n34 0.012
R7605 a_24206_4262.n9 a_24206_4262.n7 0.012
R7606 a_24206_4262.n29 a_24206_4262.n23 0.011
R7607 a_24206_4262.n30 a_24206_4262.n29 0.011
R7608 a_24206_4262.n14 a_24206_4262.n10 0.011
R7609 a_24206_4262.n38 a_24206_4262.n37 0.01
R7610 a_24206_4262.n22 a_24206_4262.n21 0.01
R7611 a_24206_4262.n21 a_24206_4262.n14 0.01
R7612 a_24206_4262.n37 a_24206_4262.n30 0.01
R7613 a_27666_2356.n10 a_27666_2356.t2 10.181
R7614 a_27666_2356.n10 a_27666_2356.t3 10.181
R7615 a_27666_2356.t0 a_27666_2356.n18 9.68
R7616 a_27666_2356.n1 a_27666_2356.n0 9.302
R7617 a_27666_2356.n7 a_27666_2356.n6 9.3
R7618 a_27666_2356.n5 a_27666_2356.n4 9.3
R7619 a_27666_2356.n9 a_27666_2356.n8 9
R7620 a_27666_2356.n13 a_27666_2356.n12 7.729
R7621 a_27666_2356.n13 a_27666_2356.n10 6.296
R7622 a_27666_2356.n16 a_27666_2356.n1 4.508
R7623 a_27666_2356.n15 a_27666_2356.n14 4.501
R7624 a_27666_2356.n15 a_27666_2356.n9 4.501
R7625 a_27666_2356.n16 a_27666_2356.n3 4.494
R7626 a_27666_2356.n18 a_27666_2356.t1 1.259
R7627 a_27666_2356.n12 a_27666_2356.n11 0.536
R7628 a_27666_2356.n18 a_27666_2356.n17 0.415
R7629 a_27666_2356.n14 a_27666_2356.n13 0.151
R7630 a_27666_2356.n7 a_27666_2356.n5 0.028
R7631 a_27666_2356.n3 a_27666_2356.n2 0.025
R7632 a_27666_2356.n17 a_27666_2356.n16 0.021
R7633 a_27666_2356.n9 a_27666_2356.n7 0.012
R7634 a_27666_2356.n16 a_27666_2356.n15 0.006
R7635 bit0.n0 bit0.t2 552.693
R7636 bit0.n5 bit0.t1 300.446
R7637 bit0.n3 bit0.t3 300.446
R7638 bit0.n0 bit0.t0 279.56
R7639 bit0.n8 bit0.n0 122.804
R7640 bit0 bit0.n8 39.444
R7641 bit0.n4 bit0.n3 27.537
R7642 bit0.n6 bit0.n5 24.127
R7643 bit0.n2 bit0.n1 8.764
R7644 bit0.n7 bit0.n6 4.661
R7645 bit0.n4 bit0.n2 3.401
R7646 bit0.n7 bit0.n4 0.626
R7647 bit0.n8 bit0.n7 0.329
R7648 a_5456_602.n26 a_5456_602.t1 10.181
R7649 a_5456_602.n18 a_5456_602.t2 10.181
R7650 a_5456_602.t0 a_5456_602.n39 9.68
R7651 a_5456_602.n3 a_5456_602.n2 9.302
R7652 a_5456_602.n13 a_5456_602.n12 9.302
R7653 a_5456_602.n32 a_5456_602.n31 9.3
R7654 a_5456_602.n34 a_5456_602.n33 9.3
R7655 a_5456_602.n7 a_5456_602.n6 9.3
R7656 a_5456_602.n5 a_5456_602.n4 9.3
R7657 a_5456_602.n36 a_5456_602.n35 9
R7658 a_5456_602.n9 a_5456_602.n8 9
R7659 a_5456_602.n27 a_5456_602.n25 7.729
R7660 a_5456_602.n19 a_5456_602.n17 7.729
R7661 a_5456_602.n27 a_5456_602.n26 6.296
R7662 a_5456_602.n19 a_5456_602.n18 6.296
R7663 a_5456_602.n30 a_5456_602.n3 4.508
R7664 a_5456_602.n14 a_5456_602.n13 4.508
R7665 a_5456_602.n37 a_5456_602.n36 4.496
R7666 a_5456_602.n21 a_5456_602.n20 4.496
R7667 a_5456_602.n29 a_5456_602.n28 4.495
R7668 a_5456_602.n10 a_5456_602.n9 4.495
R7669 a_5456_602.n14 a_5456_602.n11 4.494
R7670 a_5456_602.n30 a_5456_602.n1 4.494
R7671 a_5456_602.n39 a_5456_602.t3 1.087
R7672 a_5456_602.n25 a_5456_602.n24 0.536
R7673 a_5456_602.n17 a_5456_602.n16 0.536
R7674 a_5456_602.n39 a_5456_602.n38 0.255
R7675 a_5456_602.n28 a_5456_602.n27 0.151
R7676 a_5456_602.n20 a_5456_602.n19 0.151
R7677 a_5456_602.n23 a_5456_602.n22 0.125
R7678 a_5456_602.n34 a_5456_602.n32 0.028
R7679 a_5456_602.n7 a_5456_602.n5 0.028
R7680 a_5456_602.n1 a_5456_602.n0 0.025
R7681 a_5456_602.n20 a_5456_602.n15 0.024
R7682 a_5456_602.n36 a_5456_602.n34 0.012
R7683 a_5456_602.n9 a_5456_602.n7 0.012
R7684 a_5456_602.n29 a_5456_602.n23 0.011
R7685 a_5456_602.n30 a_5456_602.n29 0.011
R7686 a_5456_602.n14 a_5456_602.n10 0.011
R7687 a_5456_602.n38 a_5456_602.n37 0.01
R7688 a_5456_602.n22 a_5456_602.n21 0.01
R7689 a_5456_602.n21 a_5456_602.n14 0.01
R7690 a_5456_602.n37 a_5456_602.n30 0.01
R7691 a_27956_2432.n26 a_27956_2432.t1 10.181
R7692 a_27956_2432.n18 a_27956_2432.t2 10.181
R7693 a_27956_2432.t0 a_27956_2432.n39 9.68
R7694 a_27956_2432.n3 a_27956_2432.n2 9.302
R7695 a_27956_2432.n13 a_27956_2432.n12 9.302
R7696 a_27956_2432.n32 a_27956_2432.n31 9.3
R7697 a_27956_2432.n34 a_27956_2432.n33 9.3
R7698 a_27956_2432.n7 a_27956_2432.n6 9.3
R7699 a_27956_2432.n5 a_27956_2432.n4 9.3
R7700 a_27956_2432.n36 a_27956_2432.n35 9
R7701 a_27956_2432.n9 a_27956_2432.n8 9
R7702 a_27956_2432.n27 a_27956_2432.n25 7.729
R7703 a_27956_2432.n19 a_27956_2432.n17 7.729
R7704 a_27956_2432.n27 a_27956_2432.n26 6.296
R7705 a_27956_2432.n19 a_27956_2432.n18 6.296
R7706 a_27956_2432.n30 a_27956_2432.n3 4.508
R7707 a_27956_2432.n14 a_27956_2432.n13 4.508
R7708 a_27956_2432.n37 a_27956_2432.n36 4.496
R7709 a_27956_2432.n21 a_27956_2432.n20 4.496
R7710 a_27956_2432.n29 a_27956_2432.n28 4.495
R7711 a_27956_2432.n10 a_27956_2432.n9 4.495
R7712 a_27956_2432.n14 a_27956_2432.n11 4.494
R7713 a_27956_2432.n30 a_27956_2432.n1 4.494
R7714 a_27956_2432.n39 a_27956_2432.t3 1.087
R7715 a_27956_2432.n25 a_27956_2432.n24 0.536
R7716 a_27956_2432.n17 a_27956_2432.n16 0.536
R7717 a_27956_2432.n39 a_27956_2432.n38 0.255
R7718 a_27956_2432.n28 a_27956_2432.n27 0.151
R7719 a_27956_2432.n20 a_27956_2432.n19 0.151
R7720 a_27956_2432.n23 a_27956_2432.n22 0.125
R7721 a_27956_2432.n34 a_27956_2432.n32 0.028
R7722 a_27956_2432.n7 a_27956_2432.n5 0.028
R7723 a_27956_2432.n1 a_27956_2432.n0 0.025
R7724 a_27956_2432.n20 a_27956_2432.n15 0.024
R7725 a_27956_2432.n36 a_27956_2432.n34 0.012
R7726 a_27956_2432.n9 a_27956_2432.n7 0.012
R7727 a_27956_2432.n29 a_27956_2432.n23 0.011
R7728 a_27956_2432.n30 a_27956_2432.n29 0.011
R7729 a_27956_2432.n14 a_27956_2432.n10 0.011
R7730 a_27956_2432.n38 a_27956_2432.n37 0.01
R7731 a_27956_2432.n22 a_27956_2432.n21 0.01
R7732 a_27956_2432.n21 a_27956_2432.n14 0.01
R7733 a_27956_2432.n37 a_27956_2432.n30 0.01
R7734 a_12666_2356.n10 a_12666_2356.t2 10.181
R7735 a_12666_2356.n10 a_12666_2356.t3 10.181
R7736 a_12666_2356.t1 a_12666_2356.n18 9.68
R7737 a_12666_2356.n1 a_12666_2356.n0 9.302
R7738 a_12666_2356.n7 a_12666_2356.n6 9.3
R7739 a_12666_2356.n5 a_12666_2356.n4 9.3
R7740 a_12666_2356.n9 a_12666_2356.n8 9
R7741 a_12666_2356.n13 a_12666_2356.n12 7.729
R7742 a_12666_2356.n13 a_12666_2356.n10 6.296
R7743 a_12666_2356.n16 a_12666_2356.n1 4.508
R7744 a_12666_2356.n15 a_12666_2356.n14 4.501
R7745 a_12666_2356.n15 a_12666_2356.n9 4.501
R7746 a_12666_2356.n16 a_12666_2356.n3 4.494
R7747 a_12666_2356.n18 a_12666_2356.t0 1.259
R7748 a_12666_2356.n12 a_12666_2356.n11 0.536
R7749 a_12666_2356.n18 a_12666_2356.n17 0.415
R7750 a_12666_2356.n14 a_12666_2356.n13 0.151
R7751 a_12666_2356.n7 a_12666_2356.n5 0.028
R7752 a_12666_2356.n3 a_12666_2356.n2 0.025
R7753 a_12666_2356.n17 a_12666_2356.n16 0.021
R7754 a_12666_2356.n9 a_12666_2356.n7 0.012
R7755 a_12666_2356.n16 a_12666_2356.n15 0.006
R7756 a_20166_526.n10 a_20166_526.t2 10.181
R7757 a_20166_526.n10 a_20166_526.t3 10.181
R7758 a_20166_526.t1 a_20166_526.n18 9.68
R7759 a_20166_526.n1 a_20166_526.n0 9.302
R7760 a_20166_526.n7 a_20166_526.n6 9.3
R7761 a_20166_526.n5 a_20166_526.n4 9.3
R7762 a_20166_526.n9 a_20166_526.n8 9
R7763 a_20166_526.n13 a_20166_526.n12 7.729
R7764 a_20166_526.n13 a_20166_526.n10 6.296
R7765 a_20166_526.n16 a_20166_526.n1 4.508
R7766 a_20166_526.n15 a_20166_526.n14 4.501
R7767 a_20166_526.n15 a_20166_526.n9 4.501
R7768 a_20166_526.n16 a_20166_526.n3 4.494
R7769 a_20166_526.n18 a_20166_526.t0 1.259
R7770 a_20166_526.n12 a_20166_526.n11 0.536
R7771 a_20166_526.n18 a_20166_526.n17 0.415
R7772 a_20166_526.n14 a_20166_526.n13 0.151
R7773 a_20166_526.n7 a_20166_526.n5 0.028
R7774 a_20166_526.n3 a_20166_526.n2 0.025
R7775 a_20166_526.n17 a_20166_526.n16 0.021
R7776 a_20166_526.n9 a_20166_526.n7 0.012
R7777 a_20166_526.n16 a_20166_526.n15 0.006
R7778 a_16416_4186.n10 a_16416_4186.t3 10.181
R7779 a_16416_4186.n10 a_16416_4186.t2 10.181
R7780 a_16416_4186.t1 a_16416_4186.n18 9.68
R7781 a_16416_4186.n1 a_16416_4186.n0 9.302
R7782 a_16416_4186.n7 a_16416_4186.n6 9.3
R7783 a_16416_4186.n5 a_16416_4186.n4 9.3
R7784 a_16416_4186.n9 a_16416_4186.n8 9
R7785 a_16416_4186.n13 a_16416_4186.n12 7.729
R7786 a_16416_4186.n13 a_16416_4186.n10 6.296
R7787 a_16416_4186.n16 a_16416_4186.n1 4.508
R7788 a_16416_4186.n15 a_16416_4186.n14 4.501
R7789 a_16416_4186.n15 a_16416_4186.n9 4.501
R7790 a_16416_4186.n16 a_16416_4186.n3 4.494
R7791 a_16416_4186.n18 a_16416_4186.t0 1.259
R7792 a_16416_4186.n12 a_16416_4186.n11 0.536
R7793 a_16416_4186.n18 a_16416_4186.n17 0.415
R7794 a_16416_4186.n14 a_16416_4186.n13 0.151
R7795 a_16416_4186.n7 a_16416_4186.n5 0.028
R7796 a_16416_4186.n3 a_16416_4186.n2 0.025
R7797 a_16416_4186.n17 a_16416_4186.n16 0.021
R7798 a_16416_4186.n9 a_16416_4186.n7 0.012
R7799 a_16416_4186.n16 a_16416_4186.n15 0.006
R7800 a_1706_4262.n26 a_1706_4262.t2 10.181
R7801 a_1706_4262.n18 a_1706_4262.t1 10.181
R7802 a_1706_4262.t0 a_1706_4262.n39 9.68
R7803 a_1706_4262.n3 a_1706_4262.n2 9.302
R7804 a_1706_4262.n13 a_1706_4262.n12 9.302
R7805 a_1706_4262.n32 a_1706_4262.n31 9.3
R7806 a_1706_4262.n34 a_1706_4262.n33 9.3
R7807 a_1706_4262.n7 a_1706_4262.n6 9.3
R7808 a_1706_4262.n5 a_1706_4262.n4 9.3
R7809 a_1706_4262.n36 a_1706_4262.n35 9
R7810 a_1706_4262.n9 a_1706_4262.n8 9
R7811 a_1706_4262.n27 a_1706_4262.n25 7.729
R7812 a_1706_4262.n19 a_1706_4262.n17 7.729
R7813 a_1706_4262.n27 a_1706_4262.n26 6.296
R7814 a_1706_4262.n19 a_1706_4262.n18 6.296
R7815 a_1706_4262.n30 a_1706_4262.n3 4.508
R7816 a_1706_4262.n14 a_1706_4262.n13 4.508
R7817 a_1706_4262.n37 a_1706_4262.n36 4.496
R7818 a_1706_4262.n21 a_1706_4262.n20 4.496
R7819 a_1706_4262.n29 a_1706_4262.n28 4.495
R7820 a_1706_4262.n10 a_1706_4262.n9 4.495
R7821 a_1706_4262.n14 a_1706_4262.n11 4.494
R7822 a_1706_4262.n30 a_1706_4262.n1 4.494
R7823 a_1706_4262.n39 a_1706_4262.t3 1.087
R7824 a_1706_4262.n25 a_1706_4262.n24 0.536
R7825 a_1706_4262.n17 a_1706_4262.n16 0.536
R7826 a_1706_4262.n39 a_1706_4262.n38 0.255
R7827 a_1706_4262.n28 a_1706_4262.n27 0.151
R7828 a_1706_4262.n20 a_1706_4262.n19 0.151
R7829 a_1706_4262.n23 a_1706_4262.n22 0.125
R7830 a_1706_4262.n34 a_1706_4262.n32 0.028
R7831 a_1706_4262.n7 a_1706_4262.n5 0.028
R7832 a_1706_4262.n1 a_1706_4262.n0 0.025
R7833 a_1706_4262.n20 a_1706_4262.n15 0.024
R7834 a_1706_4262.n36 a_1706_4262.n34 0.012
R7835 a_1706_4262.n9 a_1706_4262.n7 0.012
R7836 a_1706_4262.n29 a_1706_4262.n23 0.011
R7837 a_1706_4262.n30 a_1706_4262.n29 0.011
R7838 a_1706_4262.n14 a_1706_4262.n10 0.011
R7839 a_1706_4262.n38 a_1706_4262.n37 0.01
R7840 a_1706_4262.n22 a_1706_4262.n21 0.01
R7841 a_1706_4262.n21 a_1706_4262.n14 0.01
R7842 a_1706_4262.n37 a_1706_4262.n30 0.01
R7843 a_16706_2432.n26 a_16706_2432.t1 10.181
R7844 a_16706_2432.n18 a_16706_2432.t2 10.181
R7845 a_16706_2432.t0 a_16706_2432.n39 9.68
R7846 a_16706_2432.n3 a_16706_2432.n2 9.302
R7847 a_16706_2432.n13 a_16706_2432.n12 9.302
R7848 a_16706_2432.n32 a_16706_2432.n31 9.3
R7849 a_16706_2432.n34 a_16706_2432.n33 9.3
R7850 a_16706_2432.n7 a_16706_2432.n6 9.3
R7851 a_16706_2432.n5 a_16706_2432.n4 9.3
R7852 a_16706_2432.n36 a_16706_2432.n35 9
R7853 a_16706_2432.n9 a_16706_2432.n8 9
R7854 a_16706_2432.n27 a_16706_2432.n25 7.729
R7855 a_16706_2432.n19 a_16706_2432.n17 7.729
R7856 a_16706_2432.n27 a_16706_2432.n26 6.296
R7857 a_16706_2432.n19 a_16706_2432.n18 6.296
R7858 a_16706_2432.n30 a_16706_2432.n3 4.508
R7859 a_16706_2432.n14 a_16706_2432.n13 4.508
R7860 a_16706_2432.n37 a_16706_2432.n36 4.496
R7861 a_16706_2432.n21 a_16706_2432.n20 4.496
R7862 a_16706_2432.n29 a_16706_2432.n28 4.495
R7863 a_16706_2432.n10 a_16706_2432.n9 4.495
R7864 a_16706_2432.n14 a_16706_2432.n11 4.494
R7865 a_16706_2432.n30 a_16706_2432.n1 4.494
R7866 a_16706_2432.n39 a_16706_2432.t3 1.087
R7867 a_16706_2432.n25 a_16706_2432.n24 0.536
R7868 a_16706_2432.n17 a_16706_2432.n16 0.536
R7869 a_16706_2432.n39 a_16706_2432.n38 0.255
R7870 a_16706_2432.n28 a_16706_2432.n27 0.151
R7871 a_16706_2432.n20 a_16706_2432.n19 0.151
R7872 a_16706_2432.n23 a_16706_2432.n22 0.125
R7873 a_16706_2432.n34 a_16706_2432.n32 0.028
R7874 a_16706_2432.n7 a_16706_2432.n5 0.028
R7875 a_16706_2432.n1 a_16706_2432.n0 0.025
R7876 a_16706_2432.n20 a_16706_2432.n15 0.024
R7877 a_16706_2432.n36 a_16706_2432.n34 0.012
R7878 a_16706_2432.n9 a_16706_2432.n7 0.012
R7879 a_16706_2432.n29 a_16706_2432.n23 0.011
R7880 a_16706_2432.n30 a_16706_2432.n29 0.011
R7881 a_16706_2432.n14 a_16706_2432.n10 0.011
R7882 a_16706_2432.n38 a_16706_2432.n37 0.01
R7883 a_16706_2432.n22 a_16706_2432.n21 0.01
R7884 a_16706_2432.n21 a_16706_2432.n14 0.01
R7885 a_16706_2432.n37 a_16706_2432.n30 0.01
R7886 a_16416_2356.n10 a_16416_2356.t2 10.181
R7887 a_16416_2356.n10 a_16416_2356.t3 10.181
R7888 a_16416_2356.t0 a_16416_2356.n18 9.68
R7889 a_16416_2356.n1 a_16416_2356.n0 9.302
R7890 a_16416_2356.n7 a_16416_2356.n6 9.3
R7891 a_16416_2356.n5 a_16416_2356.n4 9.3
R7892 a_16416_2356.n9 a_16416_2356.n8 9
R7893 a_16416_2356.n13 a_16416_2356.n12 7.729
R7894 a_16416_2356.n13 a_16416_2356.n10 6.296
R7895 a_16416_2356.n16 a_16416_2356.n1 4.508
R7896 a_16416_2356.n15 a_16416_2356.n14 4.501
R7897 a_16416_2356.n15 a_16416_2356.n9 4.501
R7898 a_16416_2356.n16 a_16416_2356.n3 4.494
R7899 a_16416_2356.n18 a_16416_2356.t1 1.259
R7900 a_16416_2356.n12 a_16416_2356.n11 0.536
R7901 a_16416_2356.n18 a_16416_2356.n17 0.415
R7902 a_16416_2356.n14 a_16416_2356.n13 0.151
R7903 a_16416_2356.n7 a_16416_2356.n5 0.028
R7904 a_16416_2356.n3 a_16416_2356.n2 0.025
R7905 a_16416_2356.n17 a_16416_2356.n16 0.021
R7906 a_16416_2356.n9 a_16416_2356.n7 0.012
R7907 a_16416_2356.n16 a_16416_2356.n15 0.006
R7908 a_23916_4186.n10 a_23916_4186.t2 10.181
R7909 a_23916_4186.n10 a_23916_4186.t3 10.181
R7910 a_23916_4186.t1 a_23916_4186.n18 9.68
R7911 a_23916_4186.n1 a_23916_4186.n0 9.302
R7912 a_23916_4186.n7 a_23916_4186.n6 9.3
R7913 a_23916_4186.n5 a_23916_4186.n4 9.3
R7914 a_23916_4186.n9 a_23916_4186.n8 9
R7915 a_23916_4186.n13 a_23916_4186.n12 7.729
R7916 a_23916_4186.n13 a_23916_4186.n10 6.296
R7917 a_23916_4186.n16 a_23916_4186.n1 4.508
R7918 a_23916_4186.n15 a_23916_4186.n14 4.501
R7919 a_23916_4186.n15 a_23916_4186.n9 4.501
R7920 a_23916_4186.n16 a_23916_4186.n3 4.494
R7921 a_23916_4186.n18 a_23916_4186.t0 1.259
R7922 a_23916_4186.n12 a_23916_4186.n11 0.536
R7923 a_23916_4186.n18 a_23916_4186.n17 0.415
R7924 a_23916_4186.n14 a_23916_4186.n13 0.151
R7925 a_23916_4186.n7 a_23916_4186.n5 0.028
R7926 a_23916_4186.n3 a_23916_4186.n2 0.025
R7927 a_23916_4186.n17 a_23916_4186.n16 0.021
R7928 a_23916_4186.n9 a_23916_4186.n7 0.012
R7929 a_23916_4186.n16 a_23916_4186.n15 0.006
R7930 a_20166_7846.n10 a_20166_7846.t2 10.181
R7931 a_20166_7846.n10 a_20166_7846.t3 10.181
R7932 a_20166_7846.t1 a_20166_7846.n18 9.68
R7933 a_20166_7846.n1 a_20166_7846.n0 9.302
R7934 a_20166_7846.n7 a_20166_7846.n6 9.3
R7935 a_20166_7846.n5 a_20166_7846.n4 9.3
R7936 a_20166_7846.n9 a_20166_7846.n8 9
R7937 a_20166_7846.n13 a_20166_7846.n12 7.729
R7938 a_20166_7846.n13 a_20166_7846.n10 6.296
R7939 a_20166_7846.n16 a_20166_7846.n1 4.508
R7940 a_20166_7846.n15 a_20166_7846.n14 4.501
R7941 a_20166_7846.n15 a_20166_7846.n9 4.501
R7942 a_20166_7846.n16 a_20166_7846.n3 4.494
R7943 a_20166_7846.n18 a_20166_7846.t0 1.259
R7944 a_20166_7846.n12 a_20166_7846.n11 0.536
R7945 a_20166_7846.n18 a_20166_7846.n17 0.415
R7946 a_20166_7846.n14 a_20166_7846.n13 0.151
R7947 a_20166_7846.n7 a_20166_7846.n5 0.028
R7948 a_20166_7846.n3 a_20166_7846.n2 0.025
R7949 a_20166_7846.n17 a_20166_7846.n16 0.021
R7950 a_20166_7846.n9 a_20166_7846.n7 0.012
R7951 a_20166_7846.n16 a_20166_7846.n15 0.006
R7952 a_12956_11582.n26 a_12956_11582.t1 10.181
R7953 a_12956_11582.n18 a_12956_11582.t0 10.181
R7954 a_12956_11582.t2 a_12956_11582.n39 9.68
R7955 a_12956_11582.n3 a_12956_11582.n2 9.302
R7956 a_12956_11582.n13 a_12956_11582.n12 9.302
R7957 a_12956_11582.n32 a_12956_11582.n31 9.3
R7958 a_12956_11582.n34 a_12956_11582.n33 9.3
R7959 a_12956_11582.n7 a_12956_11582.n6 9.3
R7960 a_12956_11582.n5 a_12956_11582.n4 9.3
R7961 a_12956_11582.n36 a_12956_11582.n35 9
R7962 a_12956_11582.n9 a_12956_11582.n8 9
R7963 a_12956_11582.n27 a_12956_11582.n25 7.729
R7964 a_12956_11582.n19 a_12956_11582.n17 7.729
R7965 a_12956_11582.n27 a_12956_11582.n26 6.296
R7966 a_12956_11582.n19 a_12956_11582.n18 6.296
R7967 a_12956_11582.n30 a_12956_11582.n3 4.508
R7968 a_12956_11582.n14 a_12956_11582.n13 4.508
R7969 a_12956_11582.n37 a_12956_11582.n36 4.496
R7970 a_12956_11582.n21 a_12956_11582.n20 4.496
R7971 a_12956_11582.n29 a_12956_11582.n28 4.495
R7972 a_12956_11582.n10 a_12956_11582.n9 4.495
R7973 a_12956_11582.n14 a_12956_11582.n11 4.494
R7974 a_12956_11582.n30 a_12956_11582.n1 4.494
R7975 a_12956_11582.n39 a_12956_11582.t3 1.087
R7976 a_12956_11582.n25 a_12956_11582.n24 0.536
R7977 a_12956_11582.n17 a_12956_11582.n16 0.536
R7978 a_12956_11582.n39 a_12956_11582.n38 0.255
R7979 a_12956_11582.n28 a_12956_11582.n27 0.151
R7980 a_12956_11582.n20 a_12956_11582.n19 0.151
R7981 a_12956_11582.n23 a_12956_11582.n22 0.125
R7982 a_12956_11582.n34 a_12956_11582.n32 0.028
R7983 a_12956_11582.n7 a_12956_11582.n5 0.028
R7984 a_12956_11582.n1 a_12956_11582.n0 0.025
R7985 a_12956_11582.n20 a_12956_11582.n15 0.024
R7986 a_12956_11582.n36 a_12956_11582.n34 0.012
R7987 a_12956_11582.n9 a_12956_11582.n7 0.012
R7988 a_12956_11582.n29 a_12956_11582.n23 0.011
R7989 a_12956_11582.n30 a_12956_11582.n29 0.011
R7990 a_12956_11582.n14 a_12956_11582.n10 0.011
R7991 a_12956_11582.n38 a_12956_11582.n37 0.01
R7992 a_12956_11582.n22 a_12956_11582.n21 0.01
R7993 a_12956_11582.n21 a_12956_11582.n14 0.01
R7994 a_12956_11582.n37 a_12956_11582.n30 0.01
R7995 a_27666_7846.n10 a_27666_7846.t2 10.181
R7996 a_27666_7846.n10 a_27666_7846.t3 10.181
R7997 a_27666_7846.t1 a_27666_7846.n18 9.68
R7998 a_27666_7846.n1 a_27666_7846.n0 9.302
R7999 a_27666_7846.n7 a_27666_7846.n6 9.3
R8000 a_27666_7846.n5 a_27666_7846.n4 9.3
R8001 a_27666_7846.n9 a_27666_7846.n8 9
R8002 a_27666_7846.n13 a_27666_7846.n12 7.729
R8003 a_27666_7846.n13 a_27666_7846.n10 6.296
R8004 a_27666_7846.n16 a_27666_7846.n1 4.508
R8005 a_27666_7846.n15 a_27666_7846.n14 4.501
R8006 a_27666_7846.n15 a_27666_7846.n9 4.501
R8007 a_27666_7846.n16 a_27666_7846.n3 4.494
R8008 a_27666_7846.n18 a_27666_7846.t0 1.259
R8009 a_27666_7846.n12 a_27666_7846.n11 0.536
R8010 a_27666_7846.n18 a_27666_7846.n17 0.415
R8011 a_27666_7846.n14 a_27666_7846.n13 0.151
R8012 a_27666_7846.n7 a_27666_7846.n5 0.028
R8013 a_27666_7846.n3 a_27666_7846.n2 0.025
R8014 a_27666_7846.n17 a_27666_7846.n16 0.021
R8015 a_27666_7846.n9 a_27666_7846.n7 0.012
R8016 a_27666_7846.n16 a_27666_7846.n15 0.006
R8017 a_20456_11582.n26 a_20456_11582.t0 10.181
R8018 a_20456_11582.n18 a_20456_11582.t1 10.181
R8019 a_20456_11582.t2 a_20456_11582.n39 9.68
R8020 a_20456_11582.n3 a_20456_11582.n2 9.302
R8021 a_20456_11582.n13 a_20456_11582.n12 9.302
R8022 a_20456_11582.n32 a_20456_11582.n31 9.3
R8023 a_20456_11582.n34 a_20456_11582.n33 9.3
R8024 a_20456_11582.n7 a_20456_11582.n6 9.3
R8025 a_20456_11582.n5 a_20456_11582.n4 9.3
R8026 a_20456_11582.n36 a_20456_11582.n35 9
R8027 a_20456_11582.n9 a_20456_11582.n8 9
R8028 a_20456_11582.n27 a_20456_11582.n25 7.729
R8029 a_20456_11582.n19 a_20456_11582.n17 7.729
R8030 a_20456_11582.n27 a_20456_11582.n26 6.296
R8031 a_20456_11582.n19 a_20456_11582.n18 6.296
R8032 a_20456_11582.n30 a_20456_11582.n3 4.508
R8033 a_20456_11582.n14 a_20456_11582.n13 4.508
R8034 a_20456_11582.n37 a_20456_11582.n36 4.496
R8035 a_20456_11582.n21 a_20456_11582.n20 4.496
R8036 a_20456_11582.n29 a_20456_11582.n28 4.495
R8037 a_20456_11582.n10 a_20456_11582.n9 4.495
R8038 a_20456_11582.n14 a_20456_11582.n11 4.494
R8039 a_20456_11582.n30 a_20456_11582.n1 4.494
R8040 a_20456_11582.n39 a_20456_11582.t3 1.087
R8041 a_20456_11582.n25 a_20456_11582.n24 0.536
R8042 a_20456_11582.n17 a_20456_11582.n16 0.536
R8043 a_20456_11582.n39 a_20456_11582.n38 0.255
R8044 a_20456_11582.n28 a_20456_11582.n27 0.151
R8045 a_20456_11582.n20 a_20456_11582.n19 0.151
R8046 a_20456_11582.n23 a_20456_11582.n22 0.125
R8047 a_20456_11582.n34 a_20456_11582.n32 0.028
R8048 a_20456_11582.n7 a_20456_11582.n5 0.028
R8049 a_20456_11582.n1 a_20456_11582.n0 0.025
R8050 a_20456_11582.n20 a_20456_11582.n15 0.024
R8051 a_20456_11582.n36 a_20456_11582.n34 0.012
R8052 a_20456_11582.n9 a_20456_11582.n7 0.012
R8053 a_20456_11582.n29 a_20456_11582.n23 0.011
R8054 a_20456_11582.n30 a_20456_11582.n29 0.011
R8055 a_20456_11582.n14 a_20456_11582.n10 0.011
R8056 a_20456_11582.n38 a_20456_11582.n37 0.01
R8057 a_20456_11582.n22 a_20456_11582.n21 0.01
R8058 a_20456_11582.n21 a_20456_11582.n14 0.01
R8059 a_20456_11582.n37 a_20456_11582.n30 0.01
R8060 a_12956_13412.n26 a_12956_13412.t1 10.181
R8061 a_12956_13412.n18 a_12956_13412.t2 10.181
R8062 a_12956_13412.t0 a_12956_13412.n39 9.68
R8063 a_12956_13412.n3 a_12956_13412.n2 9.302
R8064 a_12956_13412.n13 a_12956_13412.n12 9.302
R8065 a_12956_13412.n32 a_12956_13412.n31 9.3
R8066 a_12956_13412.n34 a_12956_13412.n33 9.3
R8067 a_12956_13412.n7 a_12956_13412.n6 9.3
R8068 a_12956_13412.n5 a_12956_13412.n4 9.3
R8069 a_12956_13412.n36 a_12956_13412.n35 9
R8070 a_12956_13412.n9 a_12956_13412.n8 9
R8071 a_12956_13412.n27 a_12956_13412.n25 7.729
R8072 a_12956_13412.n19 a_12956_13412.n17 7.729
R8073 a_12956_13412.n27 a_12956_13412.n26 6.296
R8074 a_12956_13412.n19 a_12956_13412.n18 6.296
R8075 a_12956_13412.n30 a_12956_13412.n3 4.508
R8076 a_12956_13412.n14 a_12956_13412.n13 4.508
R8077 a_12956_13412.n37 a_12956_13412.n36 4.496
R8078 a_12956_13412.n21 a_12956_13412.n20 4.496
R8079 a_12956_13412.n29 a_12956_13412.n28 4.495
R8080 a_12956_13412.n10 a_12956_13412.n9 4.495
R8081 a_12956_13412.n14 a_12956_13412.n11 4.494
R8082 a_12956_13412.n30 a_12956_13412.n1 4.494
R8083 a_12956_13412.n39 a_12956_13412.t3 1.087
R8084 a_12956_13412.n25 a_12956_13412.n24 0.536
R8085 a_12956_13412.n17 a_12956_13412.n16 0.536
R8086 a_12956_13412.n39 a_12956_13412.n38 0.255
R8087 a_12956_13412.n28 a_12956_13412.n27 0.151
R8088 a_12956_13412.n20 a_12956_13412.n19 0.151
R8089 a_12956_13412.n23 a_12956_13412.n22 0.125
R8090 a_12956_13412.n34 a_12956_13412.n32 0.028
R8091 a_12956_13412.n7 a_12956_13412.n5 0.028
R8092 a_12956_13412.n1 a_12956_13412.n0 0.025
R8093 a_12956_13412.n20 a_12956_13412.n15 0.024
R8094 a_12956_13412.n36 a_12956_13412.n34 0.012
R8095 a_12956_13412.n9 a_12956_13412.n7 0.012
R8096 a_12956_13412.n29 a_12956_13412.n23 0.011
R8097 a_12956_13412.n30 a_12956_13412.n29 0.011
R8098 a_12956_13412.n14 a_12956_13412.n10 0.011
R8099 a_12956_13412.n38 a_12956_13412.n37 0.01
R8100 a_12956_13412.n22 a_12956_13412.n21 0.01
R8101 a_12956_13412.n21 a_12956_13412.n14 0.01
R8102 a_12956_13412.n37 a_12956_13412.n30 0.01
R8103 a_9206_13412.n26 a_9206_13412.t0 10.181
R8104 a_9206_13412.n18 a_9206_13412.t1 10.181
R8105 a_9206_13412.t2 a_9206_13412.n39 9.68
R8106 a_9206_13412.n3 a_9206_13412.n2 9.302
R8107 a_9206_13412.n13 a_9206_13412.n12 9.302
R8108 a_9206_13412.n32 a_9206_13412.n31 9.3
R8109 a_9206_13412.n34 a_9206_13412.n33 9.3
R8110 a_9206_13412.n7 a_9206_13412.n6 9.3
R8111 a_9206_13412.n5 a_9206_13412.n4 9.3
R8112 a_9206_13412.n36 a_9206_13412.n35 9
R8113 a_9206_13412.n9 a_9206_13412.n8 9
R8114 a_9206_13412.n27 a_9206_13412.n25 7.729
R8115 a_9206_13412.n19 a_9206_13412.n17 7.729
R8116 a_9206_13412.n27 a_9206_13412.n26 6.296
R8117 a_9206_13412.n19 a_9206_13412.n18 6.296
R8118 a_9206_13412.n30 a_9206_13412.n3 4.508
R8119 a_9206_13412.n14 a_9206_13412.n13 4.508
R8120 a_9206_13412.n37 a_9206_13412.n36 4.496
R8121 a_9206_13412.n21 a_9206_13412.n20 4.496
R8122 a_9206_13412.n29 a_9206_13412.n28 4.495
R8123 a_9206_13412.n10 a_9206_13412.n9 4.495
R8124 a_9206_13412.n14 a_9206_13412.n11 4.494
R8125 a_9206_13412.n30 a_9206_13412.n1 4.494
R8126 a_9206_13412.n39 a_9206_13412.t3 1.087
R8127 a_9206_13412.n25 a_9206_13412.n24 0.536
R8128 a_9206_13412.n17 a_9206_13412.n16 0.536
R8129 a_9206_13412.n39 a_9206_13412.n38 0.255
R8130 a_9206_13412.n28 a_9206_13412.n27 0.151
R8131 a_9206_13412.n20 a_9206_13412.n19 0.151
R8132 a_9206_13412.n23 a_9206_13412.n22 0.125
R8133 a_9206_13412.n34 a_9206_13412.n32 0.028
R8134 a_9206_13412.n7 a_9206_13412.n5 0.028
R8135 a_9206_13412.n1 a_9206_13412.n0 0.025
R8136 a_9206_13412.n20 a_9206_13412.n15 0.024
R8137 a_9206_13412.n36 a_9206_13412.n34 0.012
R8138 a_9206_13412.n9 a_9206_13412.n7 0.012
R8139 a_9206_13412.n29 a_9206_13412.n23 0.011
R8140 a_9206_13412.n30 a_9206_13412.n29 0.011
R8141 a_9206_13412.n14 a_9206_13412.n10 0.011
R8142 a_9206_13412.n38 a_9206_13412.n37 0.01
R8143 a_9206_13412.n22 a_9206_13412.n21 0.01
R8144 a_9206_13412.n21 a_9206_13412.n14 0.01
R8145 a_9206_13412.n37 a_9206_13412.n30 0.01
R8146 a_23916_2356.n10 a_23916_2356.t3 10.181
R8147 a_23916_2356.n10 a_23916_2356.t2 10.181
R8148 a_23916_2356.t0 a_23916_2356.n18 9.68
R8149 a_23916_2356.n1 a_23916_2356.n0 9.302
R8150 a_23916_2356.n7 a_23916_2356.n6 9.3
R8151 a_23916_2356.n5 a_23916_2356.n4 9.3
R8152 a_23916_2356.n9 a_23916_2356.n8 9
R8153 a_23916_2356.n13 a_23916_2356.n12 7.729
R8154 a_23916_2356.n13 a_23916_2356.n10 6.296
R8155 a_23916_2356.n16 a_23916_2356.n1 4.508
R8156 a_23916_2356.n15 a_23916_2356.n14 4.501
R8157 a_23916_2356.n15 a_23916_2356.n9 4.501
R8158 a_23916_2356.n16 a_23916_2356.n3 4.494
R8159 a_23916_2356.n18 a_23916_2356.t1 1.259
R8160 a_23916_2356.n12 a_23916_2356.n11 0.536
R8161 a_23916_2356.n18 a_23916_2356.n17 0.415
R8162 a_23916_2356.n14 a_23916_2356.n13 0.151
R8163 a_23916_2356.n7 a_23916_2356.n5 0.028
R8164 a_23916_2356.n3 a_23916_2356.n2 0.025
R8165 a_23916_2356.n17 a_23916_2356.n16 0.021
R8166 a_23916_2356.n9 a_23916_2356.n7 0.012
R8167 a_23916_2356.n16 a_23916_2356.n15 0.006
R8168 a_9206_602.n26 a_9206_602.t1 10.181
R8169 a_9206_602.n18 a_9206_602.t2 10.181
R8170 a_9206_602.t0 a_9206_602.n39 9.68
R8171 a_9206_602.n3 a_9206_602.n2 9.302
R8172 a_9206_602.n13 a_9206_602.n12 9.302
R8173 a_9206_602.n32 a_9206_602.n31 9.3
R8174 a_9206_602.n34 a_9206_602.n33 9.3
R8175 a_9206_602.n7 a_9206_602.n6 9.3
R8176 a_9206_602.n5 a_9206_602.n4 9.3
R8177 a_9206_602.n36 a_9206_602.n35 9
R8178 a_9206_602.n9 a_9206_602.n8 9
R8179 a_9206_602.n27 a_9206_602.n25 7.729
R8180 a_9206_602.n19 a_9206_602.n17 7.729
R8181 a_9206_602.n27 a_9206_602.n26 6.296
R8182 a_9206_602.n19 a_9206_602.n18 6.296
R8183 a_9206_602.n30 a_9206_602.n3 4.508
R8184 a_9206_602.n14 a_9206_602.n13 4.508
R8185 a_9206_602.n37 a_9206_602.n36 4.496
R8186 a_9206_602.n21 a_9206_602.n20 4.496
R8187 a_9206_602.n29 a_9206_602.n28 4.495
R8188 a_9206_602.n10 a_9206_602.n9 4.495
R8189 a_9206_602.n14 a_9206_602.n11 4.494
R8190 a_9206_602.n30 a_9206_602.n1 4.494
R8191 a_9206_602.n39 a_9206_602.t3 1.087
R8192 a_9206_602.n25 a_9206_602.n24 0.536
R8193 a_9206_602.n17 a_9206_602.n16 0.536
R8194 a_9206_602.n39 a_9206_602.n38 0.255
R8195 a_9206_602.n28 a_9206_602.n27 0.151
R8196 a_9206_602.n20 a_9206_602.n19 0.151
R8197 a_9206_602.n23 a_9206_602.n22 0.125
R8198 a_9206_602.n34 a_9206_602.n32 0.028
R8199 a_9206_602.n7 a_9206_602.n5 0.028
R8200 a_9206_602.n1 a_9206_602.n0 0.025
R8201 a_9206_602.n20 a_9206_602.n15 0.024
R8202 a_9206_602.n36 a_9206_602.n34 0.012
R8203 a_9206_602.n9 a_9206_602.n7 0.012
R8204 a_9206_602.n29 a_9206_602.n23 0.011
R8205 a_9206_602.n30 a_9206_602.n29 0.011
R8206 a_9206_602.n14 a_9206_602.n10 0.011
R8207 a_9206_602.n38 a_9206_602.n37 0.01
R8208 a_9206_602.n22 a_9206_602.n21 0.01
R8209 a_9206_602.n21 a_9206_602.n14 0.01
R8210 a_9206_602.n37 a_9206_602.n30 0.01
R8211 a_8916_526.n10 a_8916_526.t2 10.181
R8212 a_8916_526.n10 a_8916_526.t3 10.181
R8213 a_8916_526.t0 a_8916_526.n18 9.68
R8214 a_8916_526.n1 a_8916_526.n0 9.302
R8215 a_8916_526.n7 a_8916_526.n6 9.3
R8216 a_8916_526.n5 a_8916_526.n4 9.3
R8217 a_8916_526.n9 a_8916_526.n8 9
R8218 a_8916_526.n13 a_8916_526.n12 7.729
R8219 a_8916_526.n13 a_8916_526.n10 6.296
R8220 a_8916_526.n16 a_8916_526.n1 4.508
R8221 a_8916_526.n15 a_8916_526.n14 4.501
R8222 a_8916_526.n15 a_8916_526.n9 4.501
R8223 a_8916_526.n16 a_8916_526.n3 4.494
R8224 a_8916_526.n18 a_8916_526.t1 1.259
R8225 a_8916_526.n12 a_8916_526.n11 0.536
R8226 a_8916_526.n18 a_8916_526.n17 0.415
R8227 a_8916_526.n14 a_8916_526.n13 0.151
R8228 a_8916_526.n7 a_8916_526.n5 0.028
R8229 a_8916_526.n3 a_8916_526.n2 0.025
R8230 a_8916_526.n17 a_8916_526.n16 0.021
R8231 a_8916_526.n9 a_8916_526.n7 0.012
R8232 a_8916_526.n16 a_8916_526.n15 0.006
R8233 a_27666_526.n10 a_27666_526.t2 10.181
R8234 a_27666_526.n10 a_27666_526.t3 10.181
R8235 a_27666_526.t0 a_27666_526.n18 9.68
R8236 a_27666_526.n1 a_27666_526.n0 9.302
R8237 a_27666_526.n7 a_27666_526.n6 9.3
R8238 a_27666_526.n5 a_27666_526.n4 9.3
R8239 a_27666_526.n9 a_27666_526.n8 9
R8240 a_27666_526.n13 a_27666_526.n12 7.729
R8241 a_27666_526.n13 a_27666_526.n10 6.296
R8242 a_27666_526.n16 a_27666_526.n1 4.508
R8243 a_27666_526.n15 a_27666_526.n14 4.501
R8244 a_27666_526.n15 a_27666_526.n9 4.501
R8245 a_27666_526.n16 a_27666_526.n3 4.494
R8246 a_27666_526.n18 a_27666_526.t1 1.259
R8247 a_27666_526.n12 a_27666_526.n11 0.536
R8248 a_27666_526.n18 a_27666_526.n17 0.415
R8249 a_27666_526.n14 a_27666_526.n13 0.151
R8250 a_27666_526.n7 a_27666_526.n5 0.028
R8251 a_27666_526.n3 a_27666_526.n2 0.025
R8252 a_27666_526.n17 a_27666_526.n16 0.021
R8253 a_27666_526.n9 a_27666_526.n7 0.012
R8254 a_27666_526.n16 a_27666_526.n15 0.006
R8255 a_16416_9676.n10 a_16416_9676.t3 10.181
R8256 a_16416_9676.n10 a_16416_9676.t2 10.181
R8257 a_16416_9676.t0 a_16416_9676.n18 9.68
R8258 a_16416_9676.n1 a_16416_9676.n0 9.302
R8259 a_16416_9676.n7 a_16416_9676.n6 9.3
R8260 a_16416_9676.n5 a_16416_9676.n4 9.3
R8261 a_16416_9676.n9 a_16416_9676.n8 9
R8262 a_16416_9676.n13 a_16416_9676.n12 7.729
R8263 a_16416_9676.n13 a_16416_9676.n10 6.296
R8264 a_16416_9676.n16 a_16416_9676.n1 4.508
R8265 a_16416_9676.n15 a_16416_9676.n14 4.501
R8266 a_16416_9676.n15 a_16416_9676.n9 4.501
R8267 a_16416_9676.n16 a_16416_9676.n3 4.494
R8268 a_16416_9676.n18 a_16416_9676.t1 1.259
R8269 a_16416_9676.n12 a_16416_9676.n11 0.536
R8270 a_16416_9676.n18 a_16416_9676.n17 0.415
R8271 a_16416_9676.n14 a_16416_9676.n13 0.151
R8272 a_16416_9676.n7 a_16416_9676.n5 0.028
R8273 a_16416_9676.n3 a_16416_9676.n2 0.025
R8274 a_16416_9676.n17 a_16416_9676.n16 0.021
R8275 a_16416_9676.n9 a_16416_9676.n7 0.012
R8276 a_16416_9676.n16 a_16416_9676.n15 0.006
R8277 a_16706_9752.n26 a_16706_9752.t3 10.181
R8278 a_16706_9752.n18 a_16706_9752.t2 10.181
R8279 a_16706_9752.t0 a_16706_9752.n39 9.68
R8280 a_16706_9752.n3 a_16706_9752.n2 9.302
R8281 a_16706_9752.n13 a_16706_9752.n12 9.302
R8282 a_16706_9752.n32 a_16706_9752.n31 9.3
R8283 a_16706_9752.n34 a_16706_9752.n33 9.3
R8284 a_16706_9752.n7 a_16706_9752.n6 9.3
R8285 a_16706_9752.n5 a_16706_9752.n4 9.3
R8286 a_16706_9752.n36 a_16706_9752.n35 9
R8287 a_16706_9752.n9 a_16706_9752.n8 9
R8288 a_16706_9752.n27 a_16706_9752.n25 7.729
R8289 a_16706_9752.n19 a_16706_9752.n17 7.729
R8290 a_16706_9752.n27 a_16706_9752.n26 6.296
R8291 a_16706_9752.n19 a_16706_9752.n18 6.296
R8292 a_16706_9752.n30 a_16706_9752.n3 4.508
R8293 a_16706_9752.n14 a_16706_9752.n13 4.508
R8294 a_16706_9752.n37 a_16706_9752.n36 4.496
R8295 a_16706_9752.n21 a_16706_9752.n20 4.496
R8296 a_16706_9752.n29 a_16706_9752.n28 4.495
R8297 a_16706_9752.n10 a_16706_9752.n9 4.495
R8298 a_16706_9752.n14 a_16706_9752.n11 4.494
R8299 a_16706_9752.n30 a_16706_9752.n1 4.494
R8300 a_16706_9752.n39 a_16706_9752.t1 1.087
R8301 a_16706_9752.n25 a_16706_9752.n24 0.536
R8302 a_16706_9752.n17 a_16706_9752.n16 0.536
R8303 a_16706_9752.n39 a_16706_9752.n38 0.255
R8304 a_16706_9752.n28 a_16706_9752.n27 0.151
R8305 a_16706_9752.n20 a_16706_9752.n19 0.151
R8306 a_16706_9752.n23 a_16706_9752.n22 0.125
R8307 a_16706_9752.n34 a_16706_9752.n32 0.028
R8308 a_16706_9752.n7 a_16706_9752.n5 0.028
R8309 a_16706_9752.n1 a_16706_9752.n0 0.025
R8310 a_16706_9752.n20 a_16706_9752.n15 0.024
R8311 a_16706_9752.n36 a_16706_9752.n34 0.012
R8312 a_16706_9752.n9 a_16706_9752.n7 0.012
R8313 a_16706_9752.n29 a_16706_9752.n23 0.011
R8314 a_16706_9752.n30 a_16706_9752.n29 0.011
R8315 a_16706_9752.n14 a_16706_9752.n10 0.011
R8316 a_16706_9752.n38 a_16706_9752.n37 0.01
R8317 a_16706_9752.n22 a_16706_9752.n21 0.01
R8318 a_16706_9752.n21 a_16706_9752.n14 0.01
R8319 a_16706_9752.n37 a_16706_9752.n30 0.01
R8320 a_5456_7922.n26 a_5456_7922.t2 10.181
R8321 a_5456_7922.n18 a_5456_7922.t3 10.181
R8322 a_5456_7922.t0 a_5456_7922.n39 9.68
R8323 a_5456_7922.n3 a_5456_7922.n2 9.302
R8324 a_5456_7922.n13 a_5456_7922.n12 9.302
R8325 a_5456_7922.n32 a_5456_7922.n31 9.3
R8326 a_5456_7922.n34 a_5456_7922.n33 9.3
R8327 a_5456_7922.n7 a_5456_7922.n6 9.3
R8328 a_5456_7922.n5 a_5456_7922.n4 9.3
R8329 a_5456_7922.n36 a_5456_7922.n35 9
R8330 a_5456_7922.n9 a_5456_7922.n8 9
R8331 a_5456_7922.n27 a_5456_7922.n25 7.729
R8332 a_5456_7922.n19 a_5456_7922.n17 7.729
R8333 a_5456_7922.n27 a_5456_7922.n26 6.296
R8334 a_5456_7922.n19 a_5456_7922.n18 6.296
R8335 a_5456_7922.n30 a_5456_7922.n3 4.508
R8336 a_5456_7922.n14 a_5456_7922.n13 4.508
R8337 a_5456_7922.n37 a_5456_7922.n36 4.496
R8338 a_5456_7922.n21 a_5456_7922.n20 4.496
R8339 a_5456_7922.n29 a_5456_7922.n28 4.495
R8340 a_5456_7922.n10 a_5456_7922.n9 4.495
R8341 a_5456_7922.n14 a_5456_7922.n11 4.494
R8342 a_5456_7922.n30 a_5456_7922.n1 4.494
R8343 a_5456_7922.n39 a_5456_7922.t1 1.087
R8344 a_5456_7922.n25 a_5456_7922.n24 0.536
R8345 a_5456_7922.n17 a_5456_7922.n16 0.536
R8346 a_5456_7922.n39 a_5456_7922.n38 0.255
R8347 a_5456_7922.n28 a_5456_7922.n27 0.151
R8348 a_5456_7922.n20 a_5456_7922.n19 0.151
R8349 a_5456_7922.n23 a_5456_7922.n22 0.125
R8350 a_5456_7922.n34 a_5456_7922.n32 0.028
R8351 a_5456_7922.n7 a_5456_7922.n5 0.028
R8352 a_5456_7922.n1 a_5456_7922.n0 0.025
R8353 a_5456_7922.n20 a_5456_7922.n15 0.024
R8354 a_5456_7922.n36 a_5456_7922.n34 0.012
R8355 a_5456_7922.n9 a_5456_7922.n7 0.012
R8356 a_5456_7922.n29 a_5456_7922.n23 0.011
R8357 a_5456_7922.n30 a_5456_7922.n29 0.011
R8358 a_5456_7922.n14 a_5456_7922.n10 0.011
R8359 a_5456_7922.n38 a_5456_7922.n37 0.01
R8360 a_5456_7922.n22 a_5456_7922.n21 0.01
R8361 a_5456_7922.n21 a_5456_7922.n14 0.01
R8362 a_5456_7922.n37 a_5456_7922.n30 0.01
R8363 a_5166_2356.n10 a_5166_2356.t2 10.181
R8364 a_5166_2356.n10 a_5166_2356.t3 10.181
R8365 a_5166_2356.t1 a_5166_2356.n18 9.68
R8366 a_5166_2356.n1 a_5166_2356.n0 9.302
R8367 a_5166_2356.n7 a_5166_2356.n6 9.3
R8368 a_5166_2356.n5 a_5166_2356.n4 9.3
R8369 a_5166_2356.n9 a_5166_2356.n8 9
R8370 a_5166_2356.n13 a_5166_2356.n12 7.729
R8371 a_5166_2356.n13 a_5166_2356.n10 6.296
R8372 a_5166_2356.n16 a_5166_2356.n1 4.508
R8373 a_5166_2356.n15 a_5166_2356.n14 4.501
R8374 a_5166_2356.n15 a_5166_2356.n9 4.501
R8375 a_5166_2356.n16 a_5166_2356.n3 4.494
R8376 a_5166_2356.n18 a_5166_2356.t0 1.259
R8377 a_5166_2356.n12 a_5166_2356.n11 0.536
R8378 a_5166_2356.n18 a_5166_2356.n17 0.415
R8379 a_5166_2356.n14 a_5166_2356.n13 0.151
R8380 a_5166_2356.n7 a_5166_2356.n5 0.028
R8381 a_5166_2356.n3 a_5166_2356.n2 0.025
R8382 a_5166_2356.n17 a_5166_2356.n16 0.021
R8383 a_5166_2356.n9 a_5166_2356.n7 0.012
R8384 a_5166_2356.n16 a_5166_2356.n15 0.006
R8385 a_9206_2432.n26 a_9206_2432.t1 10.181
R8386 a_9206_2432.n18 a_9206_2432.t2 10.181
R8387 a_9206_2432.t0 a_9206_2432.n39 9.68
R8388 a_9206_2432.n3 a_9206_2432.n2 9.302
R8389 a_9206_2432.n13 a_9206_2432.n12 9.302
R8390 a_9206_2432.n32 a_9206_2432.n31 9.3
R8391 a_9206_2432.n34 a_9206_2432.n33 9.3
R8392 a_9206_2432.n7 a_9206_2432.n6 9.3
R8393 a_9206_2432.n5 a_9206_2432.n4 9.3
R8394 a_9206_2432.n36 a_9206_2432.n35 9
R8395 a_9206_2432.n9 a_9206_2432.n8 9
R8396 a_9206_2432.n27 a_9206_2432.n25 7.729
R8397 a_9206_2432.n19 a_9206_2432.n17 7.729
R8398 a_9206_2432.n27 a_9206_2432.n26 6.296
R8399 a_9206_2432.n19 a_9206_2432.n18 6.296
R8400 a_9206_2432.n30 a_9206_2432.n3 4.508
R8401 a_9206_2432.n14 a_9206_2432.n13 4.508
R8402 a_9206_2432.n37 a_9206_2432.n36 4.496
R8403 a_9206_2432.n21 a_9206_2432.n20 4.496
R8404 a_9206_2432.n29 a_9206_2432.n28 4.495
R8405 a_9206_2432.n10 a_9206_2432.n9 4.495
R8406 a_9206_2432.n14 a_9206_2432.n11 4.494
R8407 a_9206_2432.n30 a_9206_2432.n1 4.494
R8408 a_9206_2432.n39 a_9206_2432.t3 1.087
R8409 a_9206_2432.n25 a_9206_2432.n24 0.536
R8410 a_9206_2432.n17 a_9206_2432.n16 0.536
R8411 a_9206_2432.n39 a_9206_2432.n38 0.255
R8412 a_9206_2432.n28 a_9206_2432.n27 0.151
R8413 a_9206_2432.n20 a_9206_2432.n19 0.151
R8414 a_9206_2432.n23 a_9206_2432.n22 0.125
R8415 a_9206_2432.n34 a_9206_2432.n32 0.028
R8416 a_9206_2432.n7 a_9206_2432.n5 0.028
R8417 a_9206_2432.n1 a_9206_2432.n0 0.025
R8418 a_9206_2432.n20 a_9206_2432.n15 0.024
R8419 a_9206_2432.n36 a_9206_2432.n34 0.012
R8420 a_9206_2432.n9 a_9206_2432.n7 0.012
R8421 a_9206_2432.n29 a_9206_2432.n23 0.011
R8422 a_9206_2432.n30 a_9206_2432.n29 0.011
R8423 a_9206_2432.n14 a_9206_2432.n10 0.011
R8424 a_9206_2432.n38 a_9206_2432.n37 0.01
R8425 a_9206_2432.n22 a_9206_2432.n21 0.01
R8426 a_9206_2432.n21 a_9206_2432.n14 0.01
R8427 a_9206_2432.n37 a_9206_2432.n30 0.01
R8428 a_8916_2356.n10 a_8916_2356.t2 10.181
R8429 a_8916_2356.n10 a_8916_2356.t3 10.181
R8430 a_8916_2356.t1 a_8916_2356.n18 9.68
R8431 a_8916_2356.n1 a_8916_2356.n0 9.302
R8432 a_8916_2356.n7 a_8916_2356.n6 9.3
R8433 a_8916_2356.n5 a_8916_2356.n4 9.3
R8434 a_8916_2356.n9 a_8916_2356.n8 9
R8435 a_8916_2356.n13 a_8916_2356.n12 7.729
R8436 a_8916_2356.n13 a_8916_2356.n10 6.296
R8437 a_8916_2356.n16 a_8916_2356.n1 4.508
R8438 a_8916_2356.n15 a_8916_2356.n14 4.501
R8439 a_8916_2356.n15 a_8916_2356.n9 4.501
R8440 a_8916_2356.n16 a_8916_2356.n3 4.494
R8441 a_8916_2356.n18 a_8916_2356.t0 1.259
R8442 a_8916_2356.n12 a_8916_2356.n11 0.536
R8443 a_8916_2356.n18 a_8916_2356.n17 0.415
R8444 a_8916_2356.n14 a_8916_2356.n13 0.151
R8445 a_8916_2356.n7 a_8916_2356.n5 0.028
R8446 a_8916_2356.n3 a_8916_2356.n2 0.025
R8447 a_8916_2356.n17 a_8916_2356.n16 0.021
R8448 a_8916_2356.n9 a_8916_2356.n7 0.012
R8449 a_8916_2356.n16 a_8916_2356.n15 0.006
R8450 a_27666_6016.n10 a_27666_6016.t2 10.181
R8451 a_27666_6016.n10 a_27666_6016.t3 10.181
R8452 a_27666_6016.t0 a_27666_6016.n18 9.68
R8453 a_27666_6016.n1 a_27666_6016.n0 9.302
R8454 a_27666_6016.n7 a_27666_6016.n6 9.3
R8455 a_27666_6016.n5 a_27666_6016.n4 9.3
R8456 a_27666_6016.n9 a_27666_6016.n8 9
R8457 a_27666_6016.n13 a_27666_6016.n12 7.729
R8458 a_27666_6016.n13 a_27666_6016.n10 6.296
R8459 a_27666_6016.n16 a_27666_6016.n1 4.508
R8460 a_27666_6016.n15 a_27666_6016.n14 4.501
R8461 a_27666_6016.n15 a_27666_6016.n9 4.501
R8462 a_27666_6016.n16 a_27666_6016.n3 4.494
R8463 a_27666_6016.n18 a_27666_6016.t1 1.259
R8464 a_27666_6016.n12 a_27666_6016.n11 0.536
R8465 a_27666_6016.n18 a_27666_6016.n17 0.415
R8466 a_27666_6016.n14 a_27666_6016.n13 0.151
R8467 a_27666_6016.n7 a_27666_6016.n5 0.028
R8468 a_27666_6016.n3 a_27666_6016.n2 0.025
R8469 a_27666_6016.n17 a_27666_6016.n16 0.021
R8470 a_27666_6016.n9 a_27666_6016.n7 0.012
R8471 a_27666_6016.n16 a_27666_6016.n15 0.006
R8472 a_20456_602.n26 a_20456_602.t1 10.181
R8473 a_20456_602.n18 a_20456_602.t2 10.181
R8474 a_20456_602.t0 a_20456_602.n39 9.68
R8475 a_20456_602.n3 a_20456_602.n2 9.302
R8476 a_20456_602.n13 a_20456_602.n12 9.302
R8477 a_20456_602.n32 a_20456_602.n31 9.3
R8478 a_20456_602.n34 a_20456_602.n33 9.3
R8479 a_20456_602.n7 a_20456_602.n6 9.3
R8480 a_20456_602.n5 a_20456_602.n4 9.3
R8481 a_20456_602.n36 a_20456_602.n35 9
R8482 a_20456_602.n9 a_20456_602.n8 9
R8483 a_20456_602.n27 a_20456_602.n25 7.729
R8484 a_20456_602.n19 a_20456_602.n17 7.729
R8485 a_20456_602.n27 a_20456_602.n26 6.296
R8486 a_20456_602.n19 a_20456_602.n18 6.296
R8487 a_20456_602.n30 a_20456_602.n3 4.508
R8488 a_20456_602.n14 a_20456_602.n13 4.508
R8489 a_20456_602.n37 a_20456_602.n36 4.496
R8490 a_20456_602.n21 a_20456_602.n20 4.496
R8491 a_20456_602.n29 a_20456_602.n28 4.495
R8492 a_20456_602.n10 a_20456_602.n9 4.495
R8493 a_20456_602.n14 a_20456_602.n11 4.494
R8494 a_20456_602.n30 a_20456_602.n1 4.494
R8495 a_20456_602.n39 a_20456_602.t3 1.087
R8496 a_20456_602.n25 a_20456_602.n24 0.536
R8497 a_20456_602.n17 a_20456_602.n16 0.536
R8498 a_20456_602.n39 a_20456_602.n38 0.255
R8499 a_20456_602.n28 a_20456_602.n27 0.151
R8500 a_20456_602.n20 a_20456_602.n19 0.151
R8501 a_20456_602.n23 a_20456_602.n22 0.125
R8502 a_20456_602.n34 a_20456_602.n32 0.028
R8503 a_20456_602.n7 a_20456_602.n5 0.028
R8504 a_20456_602.n1 a_20456_602.n0 0.025
R8505 a_20456_602.n20 a_20456_602.n15 0.024
R8506 a_20456_602.n36 a_20456_602.n34 0.012
R8507 a_20456_602.n9 a_20456_602.n7 0.012
R8508 a_20456_602.n29 a_20456_602.n23 0.011
R8509 a_20456_602.n30 a_20456_602.n29 0.011
R8510 a_20456_602.n14 a_20456_602.n10 0.011
R8511 a_20456_602.n38 a_20456_602.n37 0.01
R8512 a_20456_602.n22 a_20456_602.n21 0.01
R8513 a_20456_602.n21 a_20456_602.n14 0.01
R8514 a_20456_602.n37 a_20456_602.n30 0.01
R8515 a_1706_602.n26 a_1706_602.t1 10.181
R8516 a_1706_602.n18 a_1706_602.t2 10.181
R8517 a_1706_602.t0 a_1706_602.n39 9.68
R8518 a_1706_602.n3 a_1706_602.n2 9.302
R8519 a_1706_602.n13 a_1706_602.n12 9.302
R8520 a_1706_602.n32 a_1706_602.n31 9.3
R8521 a_1706_602.n34 a_1706_602.n33 9.3
R8522 a_1706_602.n7 a_1706_602.n6 9.3
R8523 a_1706_602.n5 a_1706_602.n4 9.3
R8524 a_1706_602.n36 a_1706_602.n35 9
R8525 a_1706_602.n9 a_1706_602.n8 9
R8526 a_1706_602.n27 a_1706_602.n25 7.729
R8527 a_1706_602.n19 a_1706_602.n17 7.729
R8528 a_1706_602.n27 a_1706_602.n26 6.296
R8529 a_1706_602.n19 a_1706_602.n18 6.296
R8530 a_1706_602.n30 a_1706_602.n3 4.508
R8531 a_1706_602.n14 a_1706_602.n13 4.508
R8532 a_1706_602.n37 a_1706_602.n36 4.496
R8533 a_1706_602.n21 a_1706_602.n20 4.496
R8534 a_1706_602.n29 a_1706_602.n28 4.495
R8535 a_1706_602.n10 a_1706_602.n9 4.495
R8536 a_1706_602.n14 a_1706_602.n11 4.494
R8537 a_1706_602.n30 a_1706_602.n1 4.494
R8538 a_1706_602.n39 a_1706_602.t3 1.087
R8539 a_1706_602.n25 a_1706_602.n24 0.536
R8540 a_1706_602.n17 a_1706_602.n16 0.536
R8541 a_1706_602.n39 a_1706_602.n38 0.255
R8542 a_1706_602.n28 a_1706_602.n27 0.151
R8543 a_1706_602.n20 a_1706_602.n19 0.151
R8544 a_1706_602.n23 a_1706_602.n22 0.125
R8545 a_1706_602.n34 a_1706_602.n32 0.028
R8546 a_1706_602.n7 a_1706_602.n5 0.028
R8547 a_1706_602.n1 a_1706_602.n0 0.025
R8548 a_1706_602.n20 a_1706_602.n15 0.024
R8549 a_1706_602.n36 a_1706_602.n34 0.012
R8550 a_1706_602.n9 a_1706_602.n7 0.012
R8551 a_1706_602.n29 a_1706_602.n23 0.011
R8552 a_1706_602.n30 a_1706_602.n29 0.011
R8553 a_1706_602.n14 a_1706_602.n10 0.011
R8554 a_1706_602.n38 a_1706_602.n37 0.01
R8555 a_1706_602.n22 a_1706_602.n21 0.01
R8556 a_1706_602.n21 a_1706_602.n14 0.01
R8557 a_1706_602.n37 a_1706_602.n30 0.01
R8558 a_5166_6016.n10 a_5166_6016.t2 10.181
R8559 a_5166_6016.n10 a_5166_6016.t3 10.181
R8560 a_5166_6016.t1 a_5166_6016.n18 9.68
R8561 a_5166_6016.n1 a_5166_6016.n0 9.302
R8562 a_5166_6016.n7 a_5166_6016.n6 9.3
R8563 a_5166_6016.n5 a_5166_6016.n4 9.3
R8564 a_5166_6016.n9 a_5166_6016.n8 9
R8565 a_5166_6016.n13 a_5166_6016.n12 7.729
R8566 a_5166_6016.n13 a_5166_6016.n10 6.296
R8567 a_5166_6016.n16 a_5166_6016.n1 4.508
R8568 a_5166_6016.n15 a_5166_6016.n14 4.501
R8569 a_5166_6016.n15 a_5166_6016.n9 4.501
R8570 a_5166_6016.n16 a_5166_6016.n3 4.494
R8571 a_5166_6016.n18 a_5166_6016.t0 1.259
R8572 a_5166_6016.n12 a_5166_6016.n11 0.536
R8573 a_5166_6016.n18 a_5166_6016.n17 0.415
R8574 a_5166_6016.n14 a_5166_6016.n13 0.151
R8575 a_5166_6016.n7 a_5166_6016.n5 0.028
R8576 a_5166_6016.n3 a_5166_6016.n2 0.025
R8577 a_5166_6016.n17 a_5166_6016.n16 0.021
R8578 a_5166_6016.n9 a_5166_6016.n7 0.012
R8579 a_5166_6016.n16 a_5166_6016.n15 0.006
R8580 a_1416_526.n10 a_1416_526.t2 10.181
R8581 a_1416_526.n10 a_1416_526.t3 10.181
R8582 a_1416_526.t0 a_1416_526.n18 9.68
R8583 a_1416_526.n1 a_1416_526.n0 9.302
R8584 a_1416_526.n7 a_1416_526.n6 9.3
R8585 a_1416_526.n5 a_1416_526.n4 9.3
R8586 a_1416_526.n9 a_1416_526.n8 9
R8587 a_1416_526.n13 a_1416_526.n12 7.729
R8588 a_1416_526.n13 a_1416_526.n10 6.296
R8589 a_1416_526.n16 a_1416_526.n1 4.508
R8590 a_1416_526.n15 a_1416_526.n14 4.501
R8591 a_1416_526.n15 a_1416_526.n9 4.501
R8592 a_1416_526.n16 a_1416_526.n3 4.494
R8593 a_1416_526.n18 a_1416_526.t1 1.259
R8594 a_1416_526.n12 a_1416_526.n11 0.536
R8595 a_1416_526.n18 a_1416_526.n17 0.415
R8596 a_1416_526.n14 a_1416_526.n13 0.151
R8597 a_1416_526.n7 a_1416_526.n5 0.028
R8598 a_1416_526.n3 a_1416_526.n2 0.025
R8599 a_1416_526.n17 a_1416_526.n16 0.021
R8600 a_1416_526.n9 a_1416_526.n7 0.012
R8601 a_1416_526.n16 a_1416_526.n15 0.006
R8602 a_12956_7922.n26 a_12956_7922.t2 10.181
R8603 a_12956_7922.n18 a_12956_7922.t3 10.181
R8604 a_12956_7922.t0 a_12956_7922.n39 9.68
R8605 a_12956_7922.n3 a_12956_7922.n2 9.302
R8606 a_12956_7922.n13 a_12956_7922.n12 9.302
R8607 a_12956_7922.n32 a_12956_7922.n31 9.3
R8608 a_12956_7922.n34 a_12956_7922.n33 9.3
R8609 a_12956_7922.n7 a_12956_7922.n6 9.3
R8610 a_12956_7922.n5 a_12956_7922.n4 9.3
R8611 a_12956_7922.n36 a_12956_7922.n35 9
R8612 a_12956_7922.n9 a_12956_7922.n8 9
R8613 a_12956_7922.n27 a_12956_7922.n25 7.729
R8614 a_12956_7922.n19 a_12956_7922.n17 7.729
R8615 a_12956_7922.n27 a_12956_7922.n26 6.296
R8616 a_12956_7922.n19 a_12956_7922.n18 6.296
R8617 a_12956_7922.n30 a_12956_7922.n3 4.508
R8618 a_12956_7922.n14 a_12956_7922.n13 4.508
R8619 a_12956_7922.n37 a_12956_7922.n36 4.496
R8620 a_12956_7922.n21 a_12956_7922.n20 4.496
R8621 a_12956_7922.n29 a_12956_7922.n28 4.495
R8622 a_12956_7922.n10 a_12956_7922.n9 4.495
R8623 a_12956_7922.n14 a_12956_7922.n11 4.494
R8624 a_12956_7922.n30 a_12956_7922.n1 4.494
R8625 a_12956_7922.n39 a_12956_7922.t1 1.087
R8626 a_12956_7922.n25 a_12956_7922.n24 0.536
R8627 a_12956_7922.n17 a_12956_7922.n16 0.536
R8628 a_12956_7922.n39 a_12956_7922.n38 0.255
R8629 a_12956_7922.n28 a_12956_7922.n27 0.151
R8630 a_12956_7922.n20 a_12956_7922.n19 0.151
R8631 a_12956_7922.n23 a_12956_7922.n22 0.125
R8632 a_12956_7922.n34 a_12956_7922.n32 0.028
R8633 a_12956_7922.n7 a_12956_7922.n5 0.028
R8634 a_12956_7922.n1 a_12956_7922.n0 0.025
R8635 a_12956_7922.n20 a_12956_7922.n15 0.024
R8636 a_12956_7922.n36 a_12956_7922.n34 0.012
R8637 a_12956_7922.n9 a_12956_7922.n7 0.012
R8638 a_12956_7922.n29 a_12956_7922.n23 0.011
R8639 a_12956_7922.n30 a_12956_7922.n29 0.011
R8640 a_12956_7922.n14 a_12956_7922.n10 0.011
R8641 a_12956_7922.n38 a_12956_7922.n37 0.01
R8642 a_12956_7922.n22 a_12956_7922.n21 0.01
R8643 a_12956_7922.n21 a_12956_7922.n14 0.01
R8644 a_12956_7922.n37 a_12956_7922.n30 0.01
R8645 a_1416_16996.n10 a_1416_16996.t2 10.181
R8646 a_1416_16996.n10 a_1416_16996.t1 10.181
R8647 a_1416_16996.t3 a_1416_16996.n18 9.68
R8648 a_1416_16996.n1 a_1416_16996.n0 9.302
R8649 a_1416_16996.n7 a_1416_16996.n6 9.3
R8650 a_1416_16996.n5 a_1416_16996.n4 9.3
R8651 a_1416_16996.n9 a_1416_16996.n8 9
R8652 a_1416_16996.n13 a_1416_16996.n12 7.729
R8653 a_1416_16996.n13 a_1416_16996.n10 6.296
R8654 a_1416_16996.n16 a_1416_16996.n1 4.508
R8655 a_1416_16996.n15 a_1416_16996.n14 4.501
R8656 a_1416_16996.n15 a_1416_16996.n9 4.501
R8657 a_1416_16996.n16 a_1416_16996.n3 4.494
R8658 a_1416_16996.n18 a_1416_16996.t0 1.259
R8659 a_1416_16996.n12 a_1416_16996.n11 0.536
R8660 a_1416_16996.n18 a_1416_16996.n17 0.415
R8661 a_1416_16996.n14 a_1416_16996.n13 0.151
R8662 a_1416_16996.n7 a_1416_16996.n5 0.028
R8663 a_1416_16996.n3 a_1416_16996.n2 0.025
R8664 a_1416_16996.n17 a_1416_16996.n16 0.021
R8665 a_1416_16996.n9 a_1416_16996.n7 0.012
R8666 a_1416_16996.n16 a_1416_16996.n15 0.006
R8667 VDD.n5 VDD.t8 1362.76
R8668 VDD.n24 VDD.t10 1362.76
R8669 VDD.n44 VDD.t6 1362.76
R8670 VDD.n64 VDD.t2 1362.76
R8671 VDD.n84 VDD.t0 1362.76
R8672 VDD.n104 VDD.t4 1362.76
R8673 VDD.n2 VDD.t9 145.803
R8674 VDD.n21 VDD.t11 145.803
R8675 VDD.n41 VDD.t7 145.803
R8676 VDD.n61 VDD.t3 145.803
R8677 VDD.n81 VDD.t1 145.803
R8678 VDD.n101 VDD.t5 145.803
R8679 VDD.n12 VDD.n11 35.555
R8680 VDD.n31 VDD.n30 35.555
R8681 VDD.n51 VDD.n50 35.555
R8682 VDD.n71 VDD.n70 35.555
R8683 VDD.n91 VDD.n90 35.555
R8684 VDD.n111 VDD.n110 35.555
R8685 VDD.n38 VDD.n18 9.838
R8686 VDD.n1 VDD.n0 9.3
R8687 VDD.n15 VDD.n14 9.3
R8688 VDD.n20 VDD.n19 9.3
R8689 VDD.n34 VDD.n33 9.3
R8690 VDD.n40 VDD.n39 9.3
R8691 VDD.n54 VDD.n53 9.3
R8692 VDD.n60 VDD.n59 9.3
R8693 VDD.n74 VDD.n73 9.3
R8694 VDD.n80 VDD.n79 9.3
R8695 VDD.n94 VDD.n93 9.3
R8696 VDD.n114 VDD.n113 9.3
R8697 VDD.n100 VDD.n99 9.3
R8698 VDD.n5 VDD.n4 4.68
R8699 VDD.n24 VDD.n23 4.68
R8700 VDD.n44 VDD.n43 4.68
R8701 VDD.n64 VDD.n63 4.68
R8702 VDD.n84 VDD.n83 4.68
R8703 VDD.n104 VDD.n103 4.68
R8704 VDD.n58 VDD.n38 4.45
R8705 VDD.n78 VDD.n58 2.162
R8706 VDD.n98 VDD.n78 2.162
R8707 VDD.n118 VDD.n98 2.162
R8708 VDD.n13 VDD.n3 2.007
R8709 VDD.n32 VDD.n22 2.007
R8710 VDD.n52 VDD.n42 2.007
R8711 VDD.n72 VDD.n62 2.007
R8712 VDD.n92 VDD.n82 2.007
R8713 VDD.n112 VDD.n102 2.007
R8714 VDD.n17 VDD.n1 1.651
R8715 VDD.n36 VDD.n20 1.651
R8716 VDD.n56 VDD.n40 1.651
R8717 VDD.n76 VDD.n60 1.651
R8718 VDD.n96 VDD.n80 1.651
R8719 VDD.n116 VDD.n100 1.65
R8720 VDD VDD.n118 1.075
R8721 VDD.n15 VDD.n13 1.003
R8722 VDD.n34 VDD.n32 1.003
R8723 VDD.n54 VDD.n52 1.003
R8724 VDD.n74 VDD.n72 1.003
R8725 VDD.n94 VDD.n92 1.003
R8726 VDD.n114 VDD.n112 1.003
R8727 VDD.n38 VDD.n37 0.813
R8728 VDD.n58 VDD.n57 0.813
R8729 VDD.n78 VDD.n77 0.813
R8730 VDD.n98 VDD.n97 0.813
R8731 VDD.n118 VDD.n117 0.813
R8732 VDD.n115 VDD.n114 0.535
R8733 VDD.n16 VDD.n15 0.533
R8734 VDD.n35 VDD.n34 0.533
R8735 VDD.n55 VDD.n54 0.533
R8736 VDD.n75 VDD.n74 0.533
R8737 VDD.n95 VDD.n94 0.533
R8738 VDD.n8 VDD.n7 0.501
R8739 VDD.n27 VDD.n26 0.501
R8740 VDD.n47 VDD.n46 0.501
R8741 VDD.n67 VDD.n66 0.501
R8742 VDD.n87 VDD.n86 0.501
R8743 VDD.n107 VDD.n106 0.501
R8744 VDD.n3 VDD.n2 0.125
R8745 VDD.n22 VDD.n21 0.125
R8746 VDD.n42 VDD.n41 0.125
R8747 VDD.n62 VDD.n61 0.125
R8748 VDD.n82 VDD.n81 0.125
R8749 VDD.n102 VDD.n101 0.125
R8750 VDD.n117 VDD.n116 0.05
R8751 VDD.n18 VDD.n17 0.049
R8752 VDD.n37 VDD.n36 0.049
R8753 VDD.n57 VDD.n56 0.049
R8754 VDD.n77 VDD.n76 0.049
R8755 VDD.n97 VDD.n96 0.049
R8756 VDD.n7 VDD.n6 0.032
R8757 VDD.n6 VDD.n5 0.032
R8758 VDD.n26 VDD.n25 0.032
R8759 VDD.n25 VDD.n24 0.032
R8760 VDD.n46 VDD.n45 0.032
R8761 VDD.n45 VDD.n44 0.032
R8762 VDD.n66 VDD.n65 0.032
R8763 VDD.n65 VDD.n64 0.032
R8764 VDD.n86 VDD.n85 0.032
R8765 VDD.n85 VDD.n84 0.032
R8766 VDD.n106 VDD.n105 0.032
R8767 VDD.n105 VDD.n104 0.032
R8768 VDD.n10 VDD.n9 0.008
R8769 VDD.n29 VDD.n28 0.008
R8770 VDD.n49 VDD.n48 0.008
R8771 VDD.n69 VDD.n68 0.008
R8772 VDD.n89 VDD.n88 0.008
R8773 VDD.n111 VDD.n109 0.008
R8774 VDD.n12 VDD.n10 0.007
R8775 VDD.n31 VDD.n29 0.007
R8776 VDD.n51 VDD.n49 0.007
R8777 VDD.n71 VDD.n69 0.007
R8778 VDD.n91 VDD.n89 0.007
R8779 VDD.n109 VDD.n108 0.007
R8780 VDD.n9 VDD.n8 0.007
R8781 VDD.n13 VDD.n12 0.007
R8782 VDD.n28 VDD.n27 0.007
R8783 VDD.n32 VDD.n31 0.007
R8784 VDD.n48 VDD.n47 0.007
R8785 VDD.n52 VDD.n51 0.007
R8786 VDD.n68 VDD.n67 0.007
R8787 VDD.n72 VDD.n71 0.007
R8788 VDD.n88 VDD.n87 0.007
R8789 VDD.n92 VDD.n91 0.007
R8790 VDD.n108 VDD.n107 0.007
R8791 VDD.n112 VDD.n111 0.007
R8792 VDD.n17 VDD.n16 0.003
R8793 VDD.n36 VDD.n35 0.003
R8794 VDD.n56 VDD.n55 0.003
R8795 VDD.n76 VDD.n75 0.003
R8796 VDD.n96 VDD.n95 0.003
R8797 VDD.n116 VDD.n115 0.003
R8798 a_16416_6016.n10 a_16416_6016.t3 10.181
R8799 a_16416_6016.n10 a_16416_6016.t2 10.181
R8800 a_16416_6016.t0 a_16416_6016.n18 9.68
R8801 a_16416_6016.n1 a_16416_6016.n0 9.302
R8802 a_16416_6016.n7 a_16416_6016.n6 9.3
R8803 a_16416_6016.n5 a_16416_6016.n4 9.3
R8804 a_16416_6016.n9 a_16416_6016.n8 9
R8805 a_16416_6016.n13 a_16416_6016.n12 7.729
R8806 a_16416_6016.n13 a_16416_6016.n10 6.296
R8807 a_16416_6016.n16 a_16416_6016.n1 4.508
R8808 a_16416_6016.n15 a_16416_6016.n14 4.501
R8809 a_16416_6016.n15 a_16416_6016.n9 4.501
R8810 a_16416_6016.n16 a_16416_6016.n3 4.494
R8811 a_16416_6016.n18 a_16416_6016.t1 1.259
R8812 a_16416_6016.n12 a_16416_6016.n11 0.536
R8813 a_16416_6016.n18 a_16416_6016.n17 0.415
R8814 a_16416_6016.n14 a_16416_6016.n13 0.151
R8815 a_16416_6016.n7 a_16416_6016.n5 0.028
R8816 a_16416_6016.n3 a_16416_6016.n2 0.025
R8817 a_16416_6016.n17 a_16416_6016.n16 0.021
R8818 a_16416_6016.n9 a_16416_6016.n7 0.012
R8819 a_16416_6016.n16 a_16416_6016.n15 0.006
R8820 a_16706_6092.n26 a_16706_6092.t2 10.181
R8821 a_16706_6092.n18 a_16706_6092.t1 10.181
R8822 a_16706_6092.t0 a_16706_6092.n39 9.68
R8823 a_16706_6092.n3 a_16706_6092.n2 9.302
R8824 a_16706_6092.n13 a_16706_6092.n12 9.302
R8825 a_16706_6092.n32 a_16706_6092.n31 9.3
R8826 a_16706_6092.n34 a_16706_6092.n33 9.3
R8827 a_16706_6092.n7 a_16706_6092.n6 9.3
R8828 a_16706_6092.n5 a_16706_6092.n4 9.3
R8829 a_16706_6092.n36 a_16706_6092.n35 9
R8830 a_16706_6092.n9 a_16706_6092.n8 9
R8831 a_16706_6092.n27 a_16706_6092.n25 7.729
R8832 a_16706_6092.n19 a_16706_6092.n17 7.729
R8833 a_16706_6092.n27 a_16706_6092.n26 6.296
R8834 a_16706_6092.n19 a_16706_6092.n18 6.296
R8835 a_16706_6092.n30 a_16706_6092.n3 4.508
R8836 a_16706_6092.n14 a_16706_6092.n13 4.508
R8837 a_16706_6092.n37 a_16706_6092.n36 4.496
R8838 a_16706_6092.n21 a_16706_6092.n20 4.496
R8839 a_16706_6092.n29 a_16706_6092.n28 4.495
R8840 a_16706_6092.n10 a_16706_6092.n9 4.495
R8841 a_16706_6092.n14 a_16706_6092.n11 4.494
R8842 a_16706_6092.n30 a_16706_6092.n1 4.494
R8843 a_16706_6092.n39 a_16706_6092.t3 1.087
R8844 a_16706_6092.n25 a_16706_6092.n24 0.536
R8845 a_16706_6092.n17 a_16706_6092.n16 0.536
R8846 a_16706_6092.n39 a_16706_6092.n38 0.255
R8847 a_16706_6092.n28 a_16706_6092.n27 0.151
R8848 a_16706_6092.n20 a_16706_6092.n19 0.151
R8849 a_16706_6092.n23 a_16706_6092.n22 0.125
R8850 a_16706_6092.n34 a_16706_6092.n32 0.028
R8851 a_16706_6092.n7 a_16706_6092.n5 0.028
R8852 a_16706_6092.n1 a_16706_6092.n0 0.025
R8853 a_16706_6092.n20 a_16706_6092.n15 0.024
R8854 a_16706_6092.n36 a_16706_6092.n34 0.012
R8855 a_16706_6092.n9 a_16706_6092.n7 0.012
R8856 a_16706_6092.n29 a_16706_6092.n23 0.011
R8857 a_16706_6092.n30 a_16706_6092.n29 0.011
R8858 a_16706_6092.n14 a_16706_6092.n10 0.011
R8859 a_16706_6092.n38 a_16706_6092.n37 0.01
R8860 a_16706_6092.n22 a_16706_6092.n21 0.01
R8861 a_16706_6092.n21 a_16706_6092.n14 0.01
R8862 a_16706_6092.n37 a_16706_6092.n30 0.01
R8863 a_8916_9676.n10 a_8916_9676.t3 10.181
R8864 a_8916_9676.n10 a_8916_9676.t2 10.181
R8865 a_8916_9676.t1 a_8916_9676.n18 9.68
R8866 a_8916_9676.n1 a_8916_9676.n0 9.302
R8867 a_8916_9676.n7 a_8916_9676.n6 9.3
R8868 a_8916_9676.n5 a_8916_9676.n4 9.3
R8869 a_8916_9676.n9 a_8916_9676.n8 9
R8870 a_8916_9676.n13 a_8916_9676.n12 7.729
R8871 a_8916_9676.n13 a_8916_9676.n10 6.296
R8872 a_8916_9676.n16 a_8916_9676.n1 4.508
R8873 a_8916_9676.n15 a_8916_9676.n14 4.501
R8874 a_8916_9676.n15 a_8916_9676.n9 4.501
R8875 a_8916_9676.n16 a_8916_9676.n3 4.494
R8876 a_8916_9676.n18 a_8916_9676.t0 1.259
R8877 a_8916_9676.n12 a_8916_9676.n11 0.536
R8878 a_8916_9676.n18 a_8916_9676.n17 0.415
R8879 a_8916_9676.n14 a_8916_9676.n13 0.151
R8880 a_8916_9676.n7 a_8916_9676.n5 0.028
R8881 a_8916_9676.n3 a_8916_9676.n2 0.025
R8882 a_8916_9676.n17 a_8916_9676.n16 0.021
R8883 a_8916_9676.n9 a_8916_9676.n7 0.012
R8884 a_8916_9676.n16 a_8916_9676.n15 0.006
R8885 a_9206_9752.n26 a_9206_9752.t3 10.181
R8886 a_9206_9752.n18 a_9206_9752.t2 10.181
R8887 a_9206_9752.t0 a_9206_9752.n39 9.68
R8888 a_9206_9752.n3 a_9206_9752.n2 9.302
R8889 a_9206_9752.n13 a_9206_9752.n12 9.302
R8890 a_9206_9752.n32 a_9206_9752.n31 9.3
R8891 a_9206_9752.n34 a_9206_9752.n33 9.3
R8892 a_9206_9752.n7 a_9206_9752.n6 9.3
R8893 a_9206_9752.n5 a_9206_9752.n4 9.3
R8894 a_9206_9752.n36 a_9206_9752.n35 9
R8895 a_9206_9752.n9 a_9206_9752.n8 9
R8896 a_9206_9752.n27 a_9206_9752.n25 7.729
R8897 a_9206_9752.n19 a_9206_9752.n17 7.729
R8898 a_9206_9752.n27 a_9206_9752.n26 6.296
R8899 a_9206_9752.n19 a_9206_9752.n18 6.296
R8900 a_9206_9752.n30 a_9206_9752.n3 4.508
R8901 a_9206_9752.n14 a_9206_9752.n13 4.508
R8902 a_9206_9752.n37 a_9206_9752.n36 4.496
R8903 a_9206_9752.n21 a_9206_9752.n20 4.496
R8904 a_9206_9752.n29 a_9206_9752.n28 4.495
R8905 a_9206_9752.n10 a_9206_9752.n9 4.495
R8906 a_9206_9752.n14 a_9206_9752.n11 4.494
R8907 a_9206_9752.n30 a_9206_9752.n1 4.494
R8908 a_9206_9752.n39 a_9206_9752.t1 1.087
R8909 a_9206_9752.n25 a_9206_9752.n24 0.536
R8910 a_9206_9752.n17 a_9206_9752.n16 0.536
R8911 a_9206_9752.n39 a_9206_9752.n38 0.255
R8912 a_9206_9752.n28 a_9206_9752.n27 0.151
R8913 a_9206_9752.n20 a_9206_9752.n19 0.151
R8914 a_9206_9752.n23 a_9206_9752.n22 0.125
R8915 a_9206_9752.n34 a_9206_9752.n32 0.028
R8916 a_9206_9752.n7 a_9206_9752.n5 0.028
R8917 a_9206_9752.n1 a_9206_9752.n0 0.025
R8918 a_9206_9752.n20 a_9206_9752.n15 0.024
R8919 a_9206_9752.n36 a_9206_9752.n34 0.012
R8920 a_9206_9752.n9 a_9206_9752.n7 0.012
R8921 a_9206_9752.n29 a_9206_9752.n23 0.011
R8922 a_9206_9752.n30 a_9206_9752.n29 0.011
R8923 a_9206_9752.n14 a_9206_9752.n10 0.011
R8924 a_9206_9752.n38 a_9206_9752.n37 0.01
R8925 a_9206_9752.n22 a_9206_9752.n21 0.01
R8926 a_9206_9752.n21 a_9206_9752.n14 0.01
R8927 a_9206_9752.n37 a_9206_9752.n30 0.01
R8928 a_27666_11506.n10 a_27666_11506.t2 10.181
R8929 a_27666_11506.n10 a_27666_11506.t1 10.181
R8930 a_27666_11506.t3 a_27666_11506.n18 9.68
R8931 a_27666_11506.n1 a_27666_11506.n0 9.302
R8932 a_27666_11506.n7 a_27666_11506.n6 9.3
R8933 a_27666_11506.n5 a_27666_11506.n4 9.3
R8934 a_27666_11506.n9 a_27666_11506.n8 9
R8935 a_27666_11506.n13 a_27666_11506.n12 7.729
R8936 a_27666_11506.n13 a_27666_11506.n10 6.296
R8937 a_27666_11506.n16 a_27666_11506.n1 4.508
R8938 a_27666_11506.n15 a_27666_11506.n14 4.501
R8939 a_27666_11506.n15 a_27666_11506.n9 4.501
R8940 a_27666_11506.n16 a_27666_11506.n3 4.494
R8941 a_27666_11506.n18 a_27666_11506.t0 1.259
R8942 a_27666_11506.n12 a_27666_11506.n11 0.536
R8943 a_27666_11506.n18 a_27666_11506.n17 0.415
R8944 a_27666_11506.n14 a_27666_11506.n13 0.151
R8945 a_27666_11506.n7 a_27666_11506.n5 0.028
R8946 a_27666_11506.n3 a_27666_11506.n2 0.025
R8947 a_27666_11506.n17 a_27666_11506.n16 0.021
R8948 a_27666_11506.n9 a_27666_11506.n7 0.012
R8949 a_27666_11506.n16 a_27666_11506.n15 0.006
R8950 a_23916_6016.n10 a_23916_6016.t3 10.181
R8951 a_23916_6016.n10 a_23916_6016.t2 10.181
R8952 a_23916_6016.t0 a_23916_6016.n18 9.68
R8953 a_23916_6016.n1 a_23916_6016.n0 9.302
R8954 a_23916_6016.n7 a_23916_6016.n6 9.3
R8955 a_23916_6016.n5 a_23916_6016.n4 9.3
R8956 a_23916_6016.n9 a_23916_6016.n8 9
R8957 a_23916_6016.n13 a_23916_6016.n12 7.729
R8958 a_23916_6016.n13 a_23916_6016.n10 6.296
R8959 a_23916_6016.n16 a_23916_6016.n1 4.508
R8960 a_23916_6016.n15 a_23916_6016.n14 4.501
R8961 a_23916_6016.n15 a_23916_6016.n9 4.501
R8962 a_23916_6016.n16 a_23916_6016.n3 4.494
R8963 a_23916_6016.n18 a_23916_6016.t1 1.259
R8964 a_23916_6016.n12 a_23916_6016.n11 0.536
R8965 a_23916_6016.n18 a_23916_6016.n17 0.415
R8966 a_23916_6016.n14 a_23916_6016.n13 0.151
R8967 a_23916_6016.n7 a_23916_6016.n5 0.028
R8968 a_23916_6016.n3 a_23916_6016.n2 0.025
R8969 a_23916_6016.n17 a_23916_6016.n16 0.021
R8970 a_23916_6016.n9 a_23916_6016.n7 0.012
R8971 a_23916_6016.n16 a_23916_6016.n15 0.006
R8972 a_16416_526.n10 a_16416_526.t3 10.181
R8973 a_16416_526.n10 a_16416_526.t2 10.181
R8974 a_16416_526.t1 a_16416_526.n18 9.68
R8975 a_16416_526.n1 a_16416_526.n0 9.302
R8976 a_16416_526.n7 a_16416_526.n6 9.3
R8977 a_16416_526.n5 a_16416_526.n4 9.3
R8978 a_16416_526.n9 a_16416_526.n8 9
R8979 a_16416_526.n13 a_16416_526.n12 7.729
R8980 a_16416_526.n13 a_16416_526.n10 6.296
R8981 a_16416_526.n16 a_16416_526.n1 4.508
R8982 a_16416_526.n15 a_16416_526.n14 4.501
R8983 a_16416_526.n15 a_16416_526.n9 4.501
R8984 a_16416_526.n16 a_16416_526.n3 4.494
R8985 a_16416_526.n18 a_16416_526.t0 1.259
R8986 a_16416_526.n12 a_16416_526.n11 0.536
R8987 a_16416_526.n18 a_16416_526.n17 0.415
R8988 a_16416_526.n14 a_16416_526.n13 0.151
R8989 a_16416_526.n7 a_16416_526.n5 0.028
R8990 a_16416_526.n3 a_16416_526.n2 0.025
R8991 a_16416_526.n17 a_16416_526.n16 0.021
R8992 a_16416_526.n9 a_16416_526.n7 0.012
R8993 a_16416_526.n16 a_16416_526.n15 0.006
R8994 a_16706_602.n26 a_16706_602.t2 10.181
R8995 a_16706_602.n18 a_16706_602.t1 10.181
R8996 a_16706_602.t0 a_16706_602.n39 9.68
R8997 a_16706_602.n3 a_16706_602.n2 9.302
R8998 a_16706_602.n13 a_16706_602.n12 9.302
R8999 a_16706_602.n32 a_16706_602.n31 9.3
R9000 a_16706_602.n34 a_16706_602.n33 9.3
R9001 a_16706_602.n7 a_16706_602.n6 9.3
R9002 a_16706_602.n5 a_16706_602.n4 9.3
R9003 a_16706_602.n36 a_16706_602.n35 9
R9004 a_16706_602.n9 a_16706_602.n8 9
R9005 a_16706_602.n27 a_16706_602.n25 7.729
R9006 a_16706_602.n19 a_16706_602.n17 7.729
R9007 a_16706_602.n27 a_16706_602.n26 6.296
R9008 a_16706_602.n19 a_16706_602.n18 6.296
R9009 a_16706_602.n30 a_16706_602.n3 4.508
R9010 a_16706_602.n14 a_16706_602.n13 4.508
R9011 a_16706_602.n37 a_16706_602.n36 4.496
R9012 a_16706_602.n21 a_16706_602.n20 4.496
R9013 a_16706_602.n29 a_16706_602.n28 4.495
R9014 a_16706_602.n10 a_16706_602.n9 4.495
R9015 a_16706_602.n14 a_16706_602.n11 4.494
R9016 a_16706_602.n30 a_16706_602.n1 4.494
R9017 a_16706_602.n39 a_16706_602.t3 1.087
R9018 a_16706_602.n25 a_16706_602.n24 0.536
R9019 a_16706_602.n17 a_16706_602.n16 0.536
R9020 a_16706_602.n39 a_16706_602.n38 0.255
R9021 a_16706_602.n28 a_16706_602.n27 0.151
R9022 a_16706_602.n20 a_16706_602.n19 0.151
R9023 a_16706_602.n23 a_16706_602.n22 0.125
R9024 a_16706_602.n34 a_16706_602.n32 0.028
R9025 a_16706_602.n7 a_16706_602.n5 0.028
R9026 a_16706_602.n1 a_16706_602.n0 0.025
R9027 a_16706_602.n20 a_16706_602.n15 0.024
R9028 a_16706_602.n36 a_16706_602.n34 0.012
R9029 a_16706_602.n9 a_16706_602.n7 0.012
R9030 a_16706_602.n29 a_16706_602.n23 0.011
R9031 a_16706_602.n30 a_16706_602.n29 0.011
R9032 a_16706_602.n14 a_16706_602.n10 0.011
R9033 a_16706_602.n38 a_16706_602.n37 0.01
R9034 a_16706_602.n22 a_16706_602.n21 0.01
R9035 a_16706_602.n21 a_16706_602.n14 0.01
R9036 a_16706_602.n37 a_16706_602.n30 0.01
R9037 a_12956_4262.n26 a_12956_4262.t1 10.181
R9038 a_12956_4262.n18 a_12956_4262.t2 10.181
R9039 a_12956_4262.t0 a_12956_4262.n39 9.68
R9040 a_12956_4262.n3 a_12956_4262.n2 9.302
R9041 a_12956_4262.n13 a_12956_4262.n12 9.302
R9042 a_12956_4262.n32 a_12956_4262.n31 9.3
R9043 a_12956_4262.n34 a_12956_4262.n33 9.3
R9044 a_12956_4262.n7 a_12956_4262.n6 9.3
R9045 a_12956_4262.n5 a_12956_4262.n4 9.3
R9046 a_12956_4262.n36 a_12956_4262.n35 9
R9047 a_12956_4262.n9 a_12956_4262.n8 9
R9048 a_12956_4262.n27 a_12956_4262.n25 7.729
R9049 a_12956_4262.n19 a_12956_4262.n17 7.729
R9050 a_12956_4262.n27 a_12956_4262.n26 6.296
R9051 a_12956_4262.n19 a_12956_4262.n18 6.296
R9052 a_12956_4262.n30 a_12956_4262.n3 4.508
R9053 a_12956_4262.n14 a_12956_4262.n13 4.508
R9054 a_12956_4262.n37 a_12956_4262.n36 4.496
R9055 a_12956_4262.n21 a_12956_4262.n20 4.496
R9056 a_12956_4262.n29 a_12956_4262.n28 4.495
R9057 a_12956_4262.n10 a_12956_4262.n9 4.495
R9058 a_12956_4262.n14 a_12956_4262.n11 4.494
R9059 a_12956_4262.n30 a_12956_4262.n1 4.494
R9060 a_12956_4262.n39 a_12956_4262.t3 1.087
R9061 a_12956_4262.n25 a_12956_4262.n24 0.536
R9062 a_12956_4262.n17 a_12956_4262.n16 0.536
R9063 a_12956_4262.n39 a_12956_4262.n38 0.255
R9064 a_12956_4262.n28 a_12956_4262.n27 0.151
R9065 a_12956_4262.n20 a_12956_4262.n19 0.151
R9066 a_12956_4262.n23 a_12956_4262.n22 0.125
R9067 a_12956_4262.n34 a_12956_4262.n32 0.028
R9068 a_12956_4262.n7 a_12956_4262.n5 0.028
R9069 a_12956_4262.n1 a_12956_4262.n0 0.025
R9070 a_12956_4262.n20 a_12956_4262.n15 0.024
R9071 a_12956_4262.n36 a_12956_4262.n34 0.012
R9072 a_12956_4262.n9 a_12956_4262.n7 0.012
R9073 a_12956_4262.n29 a_12956_4262.n23 0.011
R9074 a_12956_4262.n30 a_12956_4262.n29 0.011
R9075 a_12956_4262.n14 a_12956_4262.n10 0.011
R9076 a_12956_4262.n38 a_12956_4262.n37 0.01
R9077 a_12956_4262.n22 a_12956_4262.n21 0.01
R9078 a_12956_4262.n21 a_12956_4262.n14 0.01
R9079 a_12956_4262.n37 a_12956_4262.n30 0.01
R9080 a_16706_7922.n26 a_16706_7922.t3 10.181
R9081 a_16706_7922.n18 a_16706_7922.t2 10.181
R9082 a_16706_7922.t0 a_16706_7922.n39 9.68
R9083 a_16706_7922.n3 a_16706_7922.n2 9.302
R9084 a_16706_7922.n13 a_16706_7922.n12 9.302
R9085 a_16706_7922.n32 a_16706_7922.n31 9.3
R9086 a_16706_7922.n34 a_16706_7922.n33 9.3
R9087 a_16706_7922.n7 a_16706_7922.n6 9.3
R9088 a_16706_7922.n5 a_16706_7922.n4 9.3
R9089 a_16706_7922.n36 a_16706_7922.n35 9
R9090 a_16706_7922.n9 a_16706_7922.n8 9
R9091 a_16706_7922.n27 a_16706_7922.n25 7.729
R9092 a_16706_7922.n19 a_16706_7922.n17 7.729
R9093 a_16706_7922.n27 a_16706_7922.n26 6.296
R9094 a_16706_7922.n19 a_16706_7922.n18 6.296
R9095 a_16706_7922.n30 a_16706_7922.n3 4.508
R9096 a_16706_7922.n14 a_16706_7922.n13 4.508
R9097 a_16706_7922.n37 a_16706_7922.n36 4.496
R9098 a_16706_7922.n21 a_16706_7922.n20 4.496
R9099 a_16706_7922.n29 a_16706_7922.n28 4.495
R9100 a_16706_7922.n10 a_16706_7922.n9 4.495
R9101 a_16706_7922.n14 a_16706_7922.n11 4.494
R9102 a_16706_7922.n30 a_16706_7922.n1 4.494
R9103 a_16706_7922.n39 a_16706_7922.t1 1.087
R9104 a_16706_7922.n25 a_16706_7922.n24 0.536
R9105 a_16706_7922.n17 a_16706_7922.n16 0.536
R9106 a_16706_7922.n39 a_16706_7922.n38 0.255
R9107 a_16706_7922.n28 a_16706_7922.n27 0.151
R9108 a_16706_7922.n20 a_16706_7922.n19 0.151
R9109 a_16706_7922.n23 a_16706_7922.n22 0.125
R9110 a_16706_7922.n34 a_16706_7922.n32 0.028
R9111 a_16706_7922.n7 a_16706_7922.n5 0.028
R9112 a_16706_7922.n1 a_16706_7922.n0 0.025
R9113 a_16706_7922.n20 a_16706_7922.n15 0.024
R9114 a_16706_7922.n36 a_16706_7922.n34 0.012
R9115 a_16706_7922.n9 a_16706_7922.n7 0.012
R9116 a_16706_7922.n29 a_16706_7922.n23 0.011
R9117 a_16706_7922.n30 a_16706_7922.n29 0.011
R9118 a_16706_7922.n14 a_16706_7922.n10 0.011
R9119 a_16706_7922.n38 a_16706_7922.n37 0.01
R9120 a_16706_7922.n22 a_16706_7922.n21 0.01
R9121 a_16706_7922.n21 a_16706_7922.n14 0.01
R9122 a_16706_7922.n37 a_16706_7922.n30 0.01
R9123 a_20456_7922.n26 a_20456_7922.t2 10.181
R9124 a_20456_7922.n18 a_20456_7922.t3 10.181
R9125 a_20456_7922.t0 a_20456_7922.n39 9.68
R9126 a_20456_7922.n3 a_20456_7922.n2 9.302
R9127 a_20456_7922.n13 a_20456_7922.n12 9.302
R9128 a_20456_7922.n32 a_20456_7922.n31 9.3
R9129 a_20456_7922.n34 a_20456_7922.n33 9.3
R9130 a_20456_7922.n7 a_20456_7922.n6 9.3
R9131 a_20456_7922.n5 a_20456_7922.n4 9.3
R9132 a_20456_7922.n36 a_20456_7922.n35 9
R9133 a_20456_7922.n9 a_20456_7922.n8 9
R9134 a_20456_7922.n27 a_20456_7922.n25 7.729
R9135 a_20456_7922.n19 a_20456_7922.n17 7.729
R9136 a_20456_7922.n27 a_20456_7922.n26 6.296
R9137 a_20456_7922.n19 a_20456_7922.n18 6.296
R9138 a_20456_7922.n30 a_20456_7922.n3 4.508
R9139 a_20456_7922.n14 a_20456_7922.n13 4.508
R9140 a_20456_7922.n37 a_20456_7922.n36 4.496
R9141 a_20456_7922.n21 a_20456_7922.n20 4.496
R9142 a_20456_7922.n29 a_20456_7922.n28 4.495
R9143 a_20456_7922.n10 a_20456_7922.n9 4.495
R9144 a_20456_7922.n14 a_20456_7922.n11 4.494
R9145 a_20456_7922.n30 a_20456_7922.n1 4.494
R9146 a_20456_7922.n39 a_20456_7922.t1 1.087
R9147 a_20456_7922.n25 a_20456_7922.n24 0.536
R9148 a_20456_7922.n17 a_20456_7922.n16 0.536
R9149 a_20456_7922.n39 a_20456_7922.n38 0.255
R9150 a_20456_7922.n28 a_20456_7922.n27 0.151
R9151 a_20456_7922.n20 a_20456_7922.n19 0.151
R9152 a_20456_7922.n23 a_20456_7922.n22 0.125
R9153 a_20456_7922.n34 a_20456_7922.n32 0.028
R9154 a_20456_7922.n7 a_20456_7922.n5 0.028
R9155 a_20456_7922.n1 a_20456_7922.n0 0.025
R9156 a_20456_7922.n20 a_20456_7922.n15 0.024
R9157 a_20456_7922.n36 a_20456_7922.n34 0.012
R9158 a_20456_7922.n9 a_20456_7922.n7 0.012
R9159 a_20456_7922.n29 a_20456_7922.n23 0.011
R9160 a_20456_7922.n30 a_20456_7922.n29 0.011
R9161 a_20456_7922.n14 a_20456_7922.n10 0.011
R9162 a_20456_7922.n38 a_20456_7922.n37 0.01
R9163 a_20456_7922.n22 a_20456_7922.n21 0.01
R9164 a_20456_7922.n21 a_20456_7922.n14 0.01
R9165 a_20456_7922.n37 a_20456_7922.n30 0.01
R9166 a_12666_4186.n10 a_12666_4186.t2 10.181
R9167 a_12666_4186.n10 a_12666_4186.t3 10.181
R9168 a_12666_4186.t1 a_12666_4186.n18 9.68
R9169 a_12666_4186.n1 a_12666_4186.n0 9.302
R9170 a_12666_4186.n7 a_12666_4186.n6 9.3
R9171 a_12666_4186.n5 a_12666_4186.n4 9.3
R9172 a_12666_4186.n9 a_12666_4186.n8 9
R9173 a_12666_4186.n13 a_12666_4186.n12 7.729
R9174 a_12666_4186.n13 a_12666_4186.n10 6.296
R9175 a_12666_4186.n16 a_12666_4186.n1 4.508
R9176 a_12666_4186.n15 a_12666_4186.n14 4.501
R9177 a_12666_4186.n15 a_12666_4186.n9 4.501
R9178 a_12666_4186.n16 a_12666_4186.n3 4.494
R9179 a_12666_4186.n18 a_12666_4186.t0 1.259
R9180 a_12666_4186.n12 a_12666_4186.n11 0.536
R9181 a_12666_4186.n18 a_12666_4186.n17 0.415
R9182 a_12666_4186.n14 a_12666_4186.n13 0.151
R9183 a_12666_4186.n7 a_12666_4186.n5 0.028
R9184 a_12666_4186.n3 a_12666_4186.n2 0.025
R9185 a_12666_4186.n17 a_12666_4186.n16 0.021
R9186 a_12666_4186.n9 a_12666_4186.n7 0.012
R9187 a_12666_4186.n16 a_12666_4186.n15 0.006
R9188 a_27956_11582.n26 a_27956_11582.t1 10.181
R9189 a_27956_11582.n18 a_27956_11582.t0 10.181
R9190 a_27956_11582.t2 a_27956_11582.n39 9.68
R9191 a_27956_11582.n3 a_27956_11582.n2 9.302
R9192 a_27956_11582.n13 a_27956_11582.n12 9.302
R9193 a_27956_11582.n32 a_27956_11582.n31 9.3
R9194 a_27956_11582.n34 a_27956_11582.n33 9.3
R9195 a_27956_11582.n7 a_27956_11582.n6 9.3
R9196 a_27956_11582.n5 a_27956_11582.n4 9.3
R9197 a_27956_11582.n36 a_27956_11582.n35 9
R9198 a_27956_11582.n9 a_27956_11582.n8 9
R9199 a_27956_11582.n27 a_27956_11582.n25 7.729
R9200 a_27956_11582.n19 a_27956_11582.n17 7.729
R9201 a_27956_11582.n27 a_27956_11582.n26 6.296
R9202 a_27956_11582.n19 a_27956_11582.n18 6.296
R9203 a_27956_11582.n30 a_27956_11582.n3 4.508
R9204 a_27956_11582.n14 a_27956_11582.n13 4.508
R9205 a_27956_11582.n37 a_27956_11582.n36 4.496
R9206 a_27956_11582.n21 a_27956_11582.n20 4.496
R9207 a_27956_11582.n29 a_27956_11582.n28 4.495
R9208 a_27956_11582.n10 a_27956_11582.n9 4.495
R9209 a_27956_11582.n14 a_27956_11582.n11 4.494
R9210 a_27956_11582.n30 a_27956_11582.n1 4.494
R9211 a_27956_11582.n39 a_27956_11582.t3 1.087
R9212 a_27956_11582.n25 a_27956_11582.n24 0.536
R9213 a_27956_11582.n17 a_27956_11582.n16 0.536
R9214 a_27956_11582.n39 a_27956_11582.n38 0.255
R9215 a_27956_11582.n28 a_27956_11582.n27 0.151
R9216 a_27956_11582.n20 a_27956_11582.n19 0.151
R9217 a_27956_11582.n23 a_27956_11582.n22 0.125
R9218 a_27956_11582.n34 a_27956_11582.n32 0.028
R9219 a_27956_11582.n7 a_27956_11582.n5 0.028
R9220 a_27956_11582.n1 a_27956_11582.n0 0.025
R9221 a_27956_11582.n20 a_27956_11582.n15 0.024
R9222 a_27956_11582.n36 a_27956_11582.n34 0.012
R9223 a_27956_11582.n9 a_27956_11582.n7 0.012
R9224 a_27956_11582.n29 a_27956_11582.n23 0.011
R9225 a_27956_11582.n30 a_27956_11582.n29 0.011
R9226 a_27956_11582.n14 a_27956_11582.n10 0.011
R9227 a_27956_11582.n38 a_27956_11582.n37 0.01
R9228 a_27956_11582.n22 a_27956_11582.n21 0.01
R9229 a_27956_11582.n21 a_27956_11582.n14 0.01
R9230 a_27956_11582.n37 a_27956_11582.n30 0.01
R9231 a_23916_11506.n10 a_23916_11506.t2 10.181
R9232 a_23916_11506.n10 a_23916_11506.t1 10.181
R9233 a_23916_11506.t3 a_23916_11506.n18 9.68
R9234 a_23916_11506.n1 a_23916_11506.n0 9.302
R9235 a_23916_11506.n7 a_23916_11506.n6 9.3
R9236 a_23916_11506.n5 a_23916_11506.n4 9.3
R9237 a_23916_11506.n9 a_23916_11506.n8 9
R9238 a_23916_11506.n13 a_23916_11506.n12 7.729
R9239 a_23916_11506.n13 a_23916_11506.n10 6.296
R9240 a_23916_11506.n16 a_23916_11506.n1 4.508
R9241 a_23916_11506.n15 a_23916_11506.n14 4.501
R9242 a_23916_11506.n15 a_23916_11506.n9 4.501
R9243 a_23916_11506.n16 a_23916_11506.n3 4.494
R9244 a_23916_11506.n18 a_23916_11506.t0 1.259
R9245 a_23916_11506.n12 a_23916_11506.n11 0.536
R9246 a_23916_11506.n18 a_23916_11506.n17 0.415
R9247 a_23916_11506.n14 a_23916_11506.n13 0.151
R9248 a_23916_11506.n7 a_23916_11506.n5 0.028
R9249 a_23916_11506.n3 a_23916_11506.n2 0.025
R9250 a_23916_11506.n17 a_23916_11506.n16 0.021
R9251 a_23916_11506.n9 a_23916_11506.n7 0.012
R9252 a_23916_11506.n16 a_23916_11506.n15 0.006
R9253 a_20166_9676.n10 a_20166_9676.t2 10.181
R9254 a_20166_9676.n10 a_20166_9676.t3 10.181
R9255 a_20166_9676.t1 a_20166_9676.n18 9.68
R9256 a_20166_9676.n1 a_20166_9676.n0 9.302
R9257 a_20166_9676.n7 a_20166_9676.n6 9.3
R9258 a_20166_9676.n5 a_20166_9676.n4 9.3
R9259 a_20166_9676.n9 a_20166_9676.n8 9
R9260 a_20166_9676.n13 a_20166_9676.n12 7.729
R9261 a_20166_9676.n13 a_20166_9676.n10 6.296
R9262 a_20166_9676.n16 a_20166_9676.n1 4.508
R9263 a_20166_9676.n15 a_20166_9676.n14 4.501
R9264 a_20166_9676.n15 a_20166_9676.n9 4.501
R9265 a_20166_9676.n16 a_20166_9676.n3 4.494
R9266 a_20166_9676.n18 a_20166_9676.t0 1.259
R9267 a_20166_9676.n12 a_20166_9676.n11 0.536
R9268 a_20166_9676.n18 a_20166_9676.n17 0.415
R9269 a_20166_9676.n14 a_20166_9676.n13 0.151
R9270 a_20166_9676.n7 a_20166_9676.n5 0.028
R9271 a_20166_9676.n3 a_20166_9676.n2 0.025
R9272 a_20166_9676.n17 a_20166_9676.n16 0.021
R9273 a_20166_9676.n9 a_20166_9676.n7 0.012
R9274 a_20166_9676.n16 a_20166_9676.n15 0.006
R9275 a_8916_6016.n10 a_8916_6016.t3 10.181
R9276 a_8916_6016.n10 a_8916_6016.t2 10.181
R9277 a_8916_6016.t1 a_8916_6016.n18 9.68
R9278 a_8916_6016.n1 a_8916_6016.n0 9.302
R9279 a_8916_6016.n7 a_8916_6016.n6 9.3
R9280 a_8916_6016.n5 a_8916_6016.n4 9.3
R9281 a_8916_6016.n9 a_8916_6016.n8 9
R9282 a_8916_6016.n13 a_8916_6016.n12 7.729
R9283 a_8916_6016.n13 a_8916_6016.n10 6.296
R9284 a_8916_6016.n16 a_8916_6016.n1 4.508
R9285 a_8916_6016.n15 a_8916_6016.n14 4.501
R9286 a_8916_6016.n15 a_8916_6016.n9 4.501
R9287 a_8916_6016.n16 a_8916_6016.n3 4.494
R9288 a_8916_6016.n18 a_8916_6016.t0 1.259
R9289 a_8916_6016.n12 a_8916_6016.n11 0.536
R9290 a_8916_6016.n18 a_8916_6016.n17 0.415
R9291 a_8916_6016.n14 a_8916_6016.n13 0.151
R9292 a_8916_6016.n7 a_8916_6016.n5 0.028
R9293 a_8916_6016.n3 a_8916_6016.n2 0.025
R9294 a_8916_6016.n17 a_8916_6016.n16 0.021
R9295 a_8916_6016.n9 a_8916_6016.n7 0.012
R9296 a_8916_6016.n16 a_8916_6016.n15 0.006
R9297 a_9206_6092.n26 a_9206_6092.t2 10.181
R9298 a_9206_6092.n18 a_9206_6092.t1 10.181
R9299 a_9206_6092.t0 a_9206_6092.n39 9.68
R9300 a_9206_6092.n3 a_9206_6092.n2 9.302
R9301 a_9206_6092.n13 a_9206_6092.n12 9.302
R9302 a_9206_6092.n32 a_9206_6092.n31 9.3
R9303 a_9206_6092.n34 a_9206_6092.n33 9.3
R9304 a_9206_6092.n7 a_9206_6092.n6 9.3
R9305 a_9206_6092.n5 a_9206_6092.n4 9.3
R9306 a_9206_6092.n36 a_9206_6092.n35 9
R9307 a_9206_6092.n9 a_9206_6092.n8 9
R9308 a_9206_6092.n27 a_9206_6092.n25 7.729
R9309 a_9206_6092.n19 a_9206_6092.n17 7.729
R9310 a_9206_6092.n27 a_9206_6092.n26 6.296
R9311 a_9206_6092.n19 a_9206_6092.n18 6.296
R9312 a_9206_6092.n30 a_9206_6092.n3 4.508
R9313 a_9206_6092.n14 a_9206_6092.n13 4.508
R9314 a_9206_6092.n37 a_9206_6092.n36 4.496
R9315 a_9206_6092.n21 a_9206_6092.n20 4.496
R9316 a_9206_6092.n29 a_9206_6092.n28 4.495
R9317 a_9206_6092.n10 a_9206_6092.n9 4.495
R9318 a_9206_6092.n14 a_9206_6092.n11 4.494
R9319 a_9206_6092.n30 a_9206_6092.n1 4.494
R9320 a_9206_6092.n39 a_9206_6092.t3 1.087
R9321 a_9206_6092.n25 a_9206_6092.n24 0.536
R9322 a_9206_6092.n17 a_9206_6092.n16 0.536
R9323 a_9206_6092.n39 a_9206_6092.n38 0.255
R9324 a_9206_6092.n28 a_9206_6092.n27 0.151
R9325 a_9206_6092.n20 a_9206_6092.n19 0.151
R9326 a_9206_6092.n23 a_9206_6092.n22 0.125
R9327 a_9206_6092.n34 a_9206_6092.n32 0.028
R9328 a_9206_6092.n7 a_9206_6092.n5 0.028
R9329 a_9206_6092.n1 a_9206_6092.n0 0.025
R9330 a_9206_6092.n20 a_9206_6092.n15 0.024
R9331 a_9206_6092.n36 a_9206_6092.n34 0.012
R9332 a_9206_6092.n9 a_9206_6092.n7 0.012
R9333 a_9206_6092.n29 a_9206_6092.n23 0.011
R9334 a_9206_6092.n30 a_9206_6092.n29 0.011
R9335 a_9206_6092.n14 a_9206_6092.n10 0.011
R9336 a_9206_6092.n38 a_9206_6092.n37 0.01
R9337 a_9206_6092.n22 a_9206_6092.n21 0.01
R9338 a_9206_6092.n21 a_9206_6092.n14 0.01
R9339 a_9206_6092.n37 a_9206_6092.n30 0.01
R9340 a_1706_2432.n26 a_1706_2432.t1 10.181
R9341 a_1706_2432.n18 a_1706_2432.t2 10.181
R9342 a_1706_2432.t0 a_1706_2432.n39 9.68
R9343 a_1706_2432.n3 a_1706_2432.n2 9.302
R9344 a_1706_2432.n13 a_1706_2432.n12 9.302
R9345 a_1706_2432.n32 a_1706_2432.n31 9.3
R9346 a_1706_2432.n34 a_1706_2432.n33 9.3
R9347 a_1706_2432.n7 a_1706_2432.n6 9.3
R9348 a_1706_2432.n5 a_1706_2432.n4 9.3
R9349 a_1706_2432.n36 a_1706_2432.n35 9
R9350 a_1706_2432.n9 a_1706_2432.n8 9
R9351 a_1706_2432.n27 a_1706_2432.n25 7.729
R9352 a_1706_2432.n19 a_1706_2432.n17 7.729
R9353 a_1706_2432.n27 a_1706_2432.n26 6.296
R9354 a_1706_2432.n19 a_1706_2432.n18 6.296
R9355 a_1706_2432.n30 a_1706_2432.n3 4.508
R9356 a_1706_2432.n14 a_1706_2432.n13 4.508
R9357 a_1706_2432.n37 a_1706_2432.n36 4.496
R9358 a_1706_2432.n21 a_1706_2432.n20 4.496
R9359 a_1706_2432.n29 a_1706_2432.n28 4.495
R9360 a_1706_2432.n10 a_1706_2432.n9 4.495
R9361 a_1706_2432.n14 a_1706_2432.n11 4.494
R9362 a_1706_2432.n30 a_1706_2432.n1 4.494
R9363 a_1706_2432.n39 a_1706_2432.t3 1.087
R9364 a_1706_2432.n25 a_1706_2432.n24 0.536
R9365 a_1706_2432.n17 a_1706_2432.n16 0.536
R9366 a_1706_2432.n39 a_1706_2432.n38 0.255
R9367 a_1706_2432.n28 a_1706_2432.n27 0.151
R9368 a_1706_2432.n20 a_1706_2432.n19 0.151
R9369 a_1706_2432.n23 a_1706_2432.n22 0.125
R9370 a_1706_2432.n34 a_1706_2432.n32 0.028
R9371 a_1706_2432.n7 a_1706_2432.n5 0.028
R9372 a_1706_2432.n1 a_1706_2432.n0 0.025
R9373 a_1706_2432.n20 a_1706_2432.n15 0.024
R9374 a_1706_2432.n36 a_1706_2432.n34 0.012
R9375 a_1706_2432.n9 a_1706_2432.n7 0.012
R9376 a_1706_2432.n29 a_1706_2432.n23 0.011
R9377 a_1706_2432.n30 a_1706_2432.n29 0.011
R9378 a_1706_2432.n14 a_1706_2432.n10 0.011
R9379 a_1706_2432.n38 a_1706_2432.n37 0.01
R9380 a_1706_2432.n22 a_1706_2432.n21 0.01
R9381 a_1706_2432.n21 a_1706_2432.n14 0.01
R9382 a_1706_2432.n37 a_1706_2432.n30 0.01
R9383 a_1706_6092.n26 a_1706_6092.t1 10.181
R9384 a_1706_6092.n18 a_1706_6092.t2 10.181
R9385 a_1706_6092.t0 a_1706_6092.n39 9.68
R9386 a_1706_6092.n3 a_1706_6092.n2 9.302
R9387 a_1706_6092.n13 a_1706_6092.n12 9.302
R9388 a_1706_6092.n32 a_1706_6092.n31 9.3
R9389 a_1706_6092.n34 a_1706_6092.n33 9.3
R9390 a_1706_6092.n7 a_1706_6092.n6 9.3
R9391 a_1706_6092.n5 a_1706_6092.n4 9.3
R9392 a_1706_6092.n36 a_1706_6092.n35 9
R9393 a_1706_6092.n9 a_1706_6092.n8 9
R9394 a_1706_6092.n27 a_1706_6092.n25 7.729
R9395 a_1706_6092.n19 a_1706_6092.n17 7.729
R9396 a_1706_6092.n27 a_1706_6092.n26 6.296
R9397 a_1706_6092.n19 a_1706_6092.n18 6.296
R9398 a_1706_6092.n30 a_1706_6092.n3 4.508
R9399 a_1706_6092.n14 a_1706_6092.n13 4.508
R9400 a_1706_6092.n37 a_1706_6092.n36 4.496
R9401 a_1706_6092.n21 a_1706_6092.n20 4.496
R9402 a_1706_6092.n29 a_1706_6092.n28 4.495
R9403 a_1706_6092.n10 a_1706_6092.n9 4.495
R9404 a_1706_6092.n14 a_1706_6092.n11 4.494
R9405 a_1706_6092.n30 a_1706_6092.n1 4.494
R9406 a_1706_6092.n39 a_1706_6092.t3 1.087
R9407 a_1706_6092.n25 a_1706_6092.n24 0.536
R9408 a_1706_6092.n17 a_1706_6092.n16 0.536
R9409 a_1706_6092.n39 a_1706_6092.n38 0.255
R9410 a_1706_6092.n28 a_1706_6092.n27 0.151
R9411 a_1706_6092.n20 a_1706_6092.n19 0.151
R9412 a_1706_6092.n23 a_1706_6092.n22 0.125
R9413 a_1706_6092.n34 a_1706_6092.n32 0.028
R9414 a_1706_6092.n7 a_1706_6092.n5 0.028
R9415 a_1706_6092.n1 a_1706_6092.n0 0.025
R9416 a_1706_6092.n20 a_1706_6092.n15 0.024
R9417 a_1706_6092.n36 a_1706_6092.n34 0.012
R9418 a_1706_6092.n9 a_1706_6092.n7 0.012
R9419 a_1706_6092.n29 a_1706_6092.n23 0.011
R9420 a_1706_6092.n30 a_1706_6092.n29 0.011
R9421 a_1706_6092.n14 a_1706_6092.n10 0.011
R9422 a_1706_6092.n38 a_1706_6092.n37 0.01
R9423 a_1706_6092.n22 a_1706_6092.n21 0.01
R9424 a_1706_6092.n21 a_1706_6092.n14 0.01
R9425 a_1706_6092.n37 a_1706_6092.n30 0.01
R9426 a_20166_4186.n10 a_20166_4186.t2 10.181
R9427 a_20166_4186.n10 a_20166_4186.t3 10.181
R9428 a_20166_4186.t0 a_20166_4186.n18 9.68
R9429 a_20166_4186.n1 a_20166_4186.n0 9.302
R9430 a_20166_4186.n7 a_20166_4186.n6 9.3
R9431 a_20166_4186.n5 a_20166_4186.n4 9.3
R9432 a_20166_4186.n9 a_20166_4186.n8 9
R9433 a_20166_4186.n13 a_20166_4186.n12 7.729
R9434 a_20166_4186.n13 a_20166_4186.n10 6.296
R9435 a_20166_4186.n16 a_20166_4186.n1 4.508
R9436 a_20166_4186.n15 a_20166_4186.n14 4.501
R9437 a_20166_4186.n15 a_20166_4186.n9 4.501
R9438 a_20166_4186.n16 a_20166_4186.n3 4.494
R9439 a_20166_4186.n18 a_20166_4186.t1 1.259
R9440 a_20166_4186.n12 a_20166_4186.n11 0.536
R9441 a_20166_4186.n18 a_20166_4186.n17 0.415
R9442 a_20166_4186.n14 a_20166_4186.n13 0.151
R9443 a_20166_4186.n7 a_20166_4186.n5 0.028
R9444 a_20166_4186.n3 a_20166_4186.n2 0.025
R9445 a_20166_4186.n17 a_20166_4186.n16 0.021
R9446 a_20166_4186.n9 a_20166_4186.n7 0.012
R9447 a_20166_4186.n16 a_20166_4186.n15 0.006
R9448 a_5456_9752.n26 a_5456_9752.t2 10.181
R9449 a_5456_9752.n18 a_5456_9752.t3 10.181
R9450 a_5456_9752.t0 a_5456_9752.n39 9.68
R9451 a_5456_9752.n3 a_5456_9752.n2 9.302
R9452 a_5456_9752.n13 a_5456_9752.n12 9.302
R9453 a_5456_9752.n32 a_5456_9752.n31 9.3
R9454 a_5456_9752.n34 a_5456_9752.n33 9.3
R9455 a_5456_9752.n7 a_5456_9752.n6 9.3
R9456 a_5456_9752.n5 a_5456_9752.n4 9.3
R9457 a_5456_9752.n36 a_5456_9752.n35 9
R9458 a_5456_9752.n9 a_5456_9752.n8 9
R9459 a_5456_9752.n27 a_5456_9752.n25 7.729
R9460 a_5456_9752.n19 a_5456_9752.n17 7.729
R9461 a_5456_9752.n27 a_5456_9752.n26 6.296
R9462 a_5456_9752.n19 a_5456_9752.n18 6.296
R9463 a_5456_9752.n30 a_5456_9752.n3 4.508
R9464 a_5456_9752.n14 a_5456_9752.n13 4.508
R9465 a_5456_9752.n37 a_5456_9752.n36 4.496
R9466 a_5456_9752.n21 a_5456_9752.n20 4.496
R9467 a_5456_9752.n29 a_5456_9752.n28 4.495
R9468 a_5456_9752.n10 a_5456_9752.n9 4.495
R9469 a_5456_9752.n14 a_5456_9752.n11 4.494
R9470 a_5456_9752.n30 a_5456_9752.n1 4.494
R9471 a_5456_9752.n39 a_5456_9752.t1 1.087
R9472 a_5456_9752.n25 a_5456_9752.n24 0.536
R9473 a_5456_9752.n17 a_5456_9752.n16 0.536
R9474 a_5456_9752.n39 a_5456_9752.n38 0.255
R9475 a_5456_9752.n28 a_5456_9752.n27 0.151
R9476 a_5456_9752.n20 a_5456_9752.n19 0.151
R9477 a_5456_9752.n23 a_5456_9752.n22 0.125
R9478 a_5456_9752.n34 a_5456_9752.n32 0.028
R9479 a_5456_9752.n7 a_5456_9752.n5 0.028
R9480 a_5456_9752.n1 a_5456_9752.n0 0.025
R9481 a_5456_9752.n20 a_5456_9752.n15 0.024
R9482 a_5456_9752.n36 a_5456_9752.n34 0.012
R9483 a_5456_9752.n9 a_5456_9752.n7 0.012
R9484 a_5456_9752.n29 a_5456_9752.n23 0.011
R9485 a_5456_9752.n30 a_5456_9752.n29 0.011
R9486 a_5456_9752.n14 a_5456_9752.n10 0.011
R9487 a_5456_9752.n38 a_5456_9752.n37 0.01
R9488 a_5456_9752.n22 a_5456_9752.n21 0.01
R9489 a_5456_9752.n21 a_5456_9752.n14 0.01
R9490 a_5456_9752.n37 a_5456_9752.n30 0.01
R9491 a_8916_11506.n10 a_8916_11506.t2 10.181
R9492 a_8916_11506.n10 a_8916_11506.t3 10.181
R9493 a_8916_11506.t0 a_8916_11506.n18 9.68
R9494 a_8916_11506.n1 a_8916_11506.n0 9.302
R9495 a_8916_11506.n7 a_8916_11506.n6 9.3
R9496 a_8916_11506.n5 a_8916_11506.n4 9.3
R9497 a_8916_11506.n9 a_8916_11506.n8 9
R9498 a_8916_11506.n13 a_8916_11506.n12 7.729
R9499 a_8916_11506.n13 a_8916_11506.n10 6.296
R9500 a_8916_11506.n16 a_8916_11506.n1 4.508
R9501 a_8916_11506.n15 a_8916_11506.n14 4.501
R9502 a_8916_11506.n15 a_8916_11506.n9 4.501
R9503 a_8916_11506.n16 a_8916_11506.n3 4.494
R9504 a_8916_11506.n18 a_8916_11506.t1 1.259
R9505 a_8916_11506.n12 a_8916_11506.n11 0.536
R9506 a_8916_11506.n18 a_8916_11506.n17 0.415
R9507 a_8916_11506.n14 a_8916_11506.n13 0.151
R9508 a_8916_11506.n7 a_8916_11506.n5 0.028
R9509 a_8916_11506.n3 a_8916_11506.n2 0.025
R9510 a_8916_11506.n17 a_8916_11506.n16 0.021
R9511 a_8916_11506.n9 a_8916_11506.n7 0.012
R9512 a_8916_11506.n16 a_8916_11506.n15 0.006
R9513 a_16706_11582.n26 a_16706_11582.t1 10.181
R9514 a_16706_11582.n18 a_16706_11582.t0 10.181
R9515 a_16706_11582.t2 a_16706_11582.n39 9.68
R9516 a_16706_11582.n3 a_16706_11582.n2 9.302
R9517 a_16706_11582.n13 a_16706_11582.n12 9.302
R9518 a_16706_11582.n32 a_16706_11582.n31 9.3
R9519 a_16706_11582.n34 a_16706_11582.n33 9.3
R9520 a_16706_11582.n7 a_16706_11582.n6 9.3
R9521 a_16706_11582.n5 a_16706_11582.n4 9.3
R9522 a_16706_11582.n36 a_16706_11582.n35 9
R9523 a_16706_11582.n9 a_16706_11582.n8 9
R9524 a_16706_11582.n27 a_16706_11582.n25 7.729
R9525 a_16706_11582.n19 a_16706_11582.n17 7.729
R9526 a_16706_11582.n27 a_16706_11582.n26 6.296
R9527 a_16706_11582.n19 a_16706_11582.n18 6.296
R9528 a_16706_11582.n30 a_16706_11582.n3 4.508
R9529 a_16706_11582.n14 a_16706_11582.n13 4.508
R9530 a_16706_11582.n37 a_16706_11582.n36 4.496
R9531 a_16706_11582.n21 a_16706_11582.n20 4.496
R9532 a_16706_11582.n29 a_16706_11582.n28 4.495
R9533 a_16706_11582.n10 a_16706_11582.n9 4.495
R9534 a_16706_11582.n14 a_16706_11582.n11 4.494
R9535 a_16706_11582.n30 a_16706_11582.n1 4.494
R9536 a_16706_11582.n39 a_16706_11582.t3 1.087
R9537 a_16706_11582.n25 a_16706_11582.n24 0.536
R9538 a_16706_11582.n17 a_16706_11582.n16 0.536
R9539 a_16706_11582.n39 a_16706_11582.n38 0.255
R9540 a_16706_11582.n28 a_16706_11582.n27 0.151
R9541 a_16706_11582.n20 a_16706_11582.n19 0.151
R9542 a_16706_11582.n23 a_16706_11582.n22 0.125
R9543 a_16706_11582.n34 a_16706_11582.n32 0.028
R9544 a_16706_11582.n7 a_16706_11582.n5 0.028
R9545 a_16706_11582.n1 a_16706_11582.n0 0.025
R9546 a_16706_11582.n20 a_16706_11582.n15 0.024
R9547 a_16706_11582.n36 a_16706_11582.n34 0.012
R9548 a_16706_11582.n9 a_16706_11582.n7 0.012
R9549 a_16706_11582.n29 a_16706_11582.n23 0.011
R9550 a_16706_11582.n30 a_16706_11582.n29 0.011
R9551 a_16706_11582.n14 a_16706_11582.n10 0.011
R9552 a_16706_11582.n38 a_16706_11582.n37 0.01
R9553 a_16706_11582.n22 a_16706_11582.n21 0.01
R9554 a_16706_11582.n21 a_16706_11582.n14 0.01
R9555 a_16706_11582.n37 a_16706_11582.n30 0.01
R9556 a_1416_2356.n10 a_1416_2356.t3 10.181
R9557 a_1416_2356.n10 a_1416_2356.t2 10.181
R9558 a_1416_2356.t1 a_1416_2356.n18 9.68
R9559 a_1416_2356.n1 a_1416_2356.n0 9.302
R9560 a_1416_2356.n7 a_1416_2356.n6 9.3
R9561 a_1416_2356.n5 a_1416_2356.n4 9.3
R9562 a_1416_2356.n9 a_1416_2356.n8 9
R9563 a_1416_2356.n13 a_1416_2356.n12 7.729
R9564 a_1416_2356.n13 a_1416_2356.n10 6.296
R9565 a_1416_2356.n16 a_1416_2356.n1 4.508
R9566 a_1416_2356.n15 a_1416_2356.n14 4.501
R9567 a_1416_2356.n15 a_1416_2356.n9 4.501
R9568 a_1416_2356.n16 a_1416_2356.n3 4.494
R9569 a_1416_2356.n18 a_1416_2356.t0 1.259
R9570 a_1416_2356.n12 a_1416_2356.n11 0.536
R9571 a_1416_2356.n18 a_1416_2356.n17 0.415
R9572 a_1416_2356.n14 a_1416_2356.n13 0.151
R9573 a_1416_2356.n7 a_1416_2356.n5 0.028
R9574 a_1416_2356.n3 a_1416_2356.n2 0.025
R9575 a_1416_2356.n17 a_1416_2356.n16 0.021
R9576 a_1416_2356.n9 a_1416_2356.n7 0.012
R9577 a_1416_2356.n16 a_1416_2356.n15 0.006
R9578 a_5456_2432.n26 a_5456_2432.t1 10.181
R9579 a_5456_2432.n18 a_5456_2432.t2 10.181
R9580 a_5456_2432.t0 a_5456_2432.n39 9.68
R9581 a_5456_2432.n3 a_5456_2432.n2 9.302
R9582 a_5456_2432.n13 a_5456_2432.n12 9.302
R9583 a_5456_2432.n32 a_5456_2432.n31 9.3
R9584 a_5456_2432.n34 a_5456_2432.n33 9.3
R9585 a_5456_2432.n7 a_5456_2432.n6 9.3
R9586 a_5456_2432.n5 a_5456_2432.n4 9.3
R9587 a_5456_2432.n36 a_5456_2432.n35 9
R9588 a_5456_2432.n9 a_5456_2432.n8 9
R9589 a_5456_2432.n27 a_5456_2432.n25 7.729
R9590 a_5456_2432.n19 a_5456_2432.n17 7.729
R9591 a_5456_2432.n27 a_5456_2432.n26 6.296
R9592 a_5456_2432.n19 a_5456_2432.n18 6.296
R9593 a_5456_2432.n30 a_5456_2432.n3 4.508
R9594 a_5456_2432.n14 a_5456_2432.n13 4.508
R9595 a_5456_2432.n37 a_5456_2432.n36 4.496
R9596 a_5456_2432.n21 a_5456_2432.n20 4.496
R9597 a_5456_2432.n29 a_5456_2432.n28 4.495
R9598 a_5456_2432.n10 a_5456_2432.n9 4.495
R9599 a_5456_2432.n14 a_5456_2432.n11 4.494
R9600 a_5456_2432.n30 a_5456_2432.n1 4.494
R9601 a_5456_2432.n39 a_5456_2432.t3 1.087
R9602 a_5456_2432.n25 a_5456_2432.n24 0.536
R9603 a_5456_2432.n17 a_5456_2432.n16 0.536
R9604 a_5456_2432.n39 a_5456_2432.n38 0.255
R9605 a_5456_2432.n28 a_5456_2432.n27 0.151
R9606 a_5456_2432.n20 a_5456_2432.n19 0.151
R9607 a_5456_2432.n23 a_5456_2432.n22 0.125
R9608 a_5456_2432.n34 a_5456_2432.n32 0.028
R9609 a_5456_2432.n7 a_5456_2432.n5 0.028
R9610 a_5456_2432.n1 a_5456_2432.n0 0.025
R9611 a_5456_2432.n20 a_5456_2432.n15 0.024
R9612 a_5456_2432.n36 a_5456_2432.n34 0.012
R9613 a_5456_2432.n9 a_5456_2432.n7 0.012
R9614 a_5456_2432.n29 a_5456_2432.n23 0.011
R9615 a_5456_2432.n30 a_5456_2432.n29 0.011
R9616 a_5456_2432.n14 a_5456_2432.n10 0.011
R9617 a_5456_2432.n38 a_5456_2432.n37 0.01
R9618 a_5456_2432.n22 a_5456_2432.n21 0.01
R9619 a_5456_2432.n21 a_5456_2432.n14 0.01
R9620 a_5456_2432.n37 a_5456_2432.n30 0.01
R9621 a_20166_2356.n10 a_20166_2356.t2 10.181
R9622 a_20166_2356.n10 a_20166_2356.t3 10.181
R9623 a_20166_2356.t1 a_20166_2356.n18 9.68
R9624 a_20166_2356.n1 a_20166_2356.n0 9.302
R9625 a_20166_2356.n7 a_20166_2356.n6 9.3
R9626 a_20166_2356.n5 a_20166_2356.n4 9.3
R9627 a_20166_2356.n9 a_20166_2356.n8 9
R9628 a_20166_2356.n13 a_20166_2356.n12 7.729
R9629 a_20166_2356.n13 a_20166_2356.n10 6.296
R9630 a_20166_2356.n16 a_20166_2356.n1 4.508
R9631 a_20166_2356.n15 a_20166_2356.n14 4.501
R9632 a_20166_2356.n15 a_20166_2356.n9 4.501
R9633 a_20166_2356.n16 a_20166_2356.n3 4.494
R9634 a_20166_2356.n18 a_20166_2356.t0 1.259
R9635 a_20166_2356.n12 a_20166_2356.n11 0.536
R9636 a_20166_2356.n18 a_20166_2356.n17 0.415
R9637 a_20166_2356.n14 a_20166_2356.n13 0.151
R9638 a_20166_2356.n7 a_20166_2356.n5 0.028
R9639 a_20166_2356.n3 a_20166_2356.n2 0.025
R9640 a_20166_2356.n17 a_20166_2356.n16 0.021
R9641 a_20166_2356.n9 a_20166_2356.n7 0.012
R9642 a_20166_2356.n16 a_20166_2356.n15 0.006
R9643 a_9206_4262.n26 a_9206_4262.t2 10.181
R9644 a_9206_4262.n18 a_9206_4262.t1 10.181
R9645 a_9206_4262.t0 a_9206_4262.n39 9.68
R9646 a_9206_4262.n3 a_9206_4262.n2 9.302
R9647 a_9206_4262.n13 a_9206_4262.n12 9.302
R9648 a_9206_4262.n32 a_9206_4262.n31 9.3
R9649 a_9206_4262.n34 a_9206_4262.n33 9.3
R9650 a_9206_4262.n7 a_9206_4262.n6 9.3
R9651 a_9206_4262.n5 a_9206_4262.n4 9.3
R9652 a_9206_4262.n36 a_9206_4262.n35 9
R9653 a_9206_4262.n9 a_9206_4262.n8 9
R9654 a_9206_4262.n27 a_9206_4262.n25 7.729
R9655 a_9206_4262.n19 a_9206_4262.n17 7.729
R9656 a_9206_4262.n27 a_9206_4262.n26 6.296
R9657 a_9206_4262.n19 a_9206_4262.n18 6.296
R9658 a_9206_4262.n30 a_9206_4262.n3 4.508
R9659 a_9206_4262.n14 a_9206_4262.n13 4.508
R9660 a_9206_4262.n37 a_9206_4262.n36 4.496
R9661 a_9206_4262.n21 a_9206_4262.n20 4.496
R9662 a_9206_4262.n29 a_9206_4262.n28 4.495
R9663 a_9206_4262.n10 a_9206_4262.n9 4.495
R9664 a_9206_4262.n14 a_9206_4262.n11 4.494
R9665 a_9206_4262.n30 a_9206_4262.n1 4.494
R9666 a_9206_4262.n39 a_9206_4262.t3 1.087
R9667 a_9206_4262.n25 a_9206_4262.n24 0.536
R9668 a_9206_4262.n17 a_9206_4262.n16 0.536
R9669 a_9206_4262.n39 a_9206_4262.n38 0.255
R9670 a_9206_4262.n28 a_9206_4262.n27 0.151
R9671 a_9206_4262.n20 a_9206_4262.n19 0.151
R9672 a_9206_4262.n23 a_9206_4262.n22 0.125
R9673 a_9206_4262.n34 a_9206_4262.n32 0.028
R9674 a_9206_4262.n7 a_9206_4262.n5 0.028
R9675 a_9206_4262.n1 a_9206_4262.n0 0.025
R9676 a_9206_4262.n20 a_9206_4262.n15 0.024
R9677 a_9206_4262.n36 a_9206_4262.n34 0.012
R9678 a_9206_4262.n9 a_9206_4262.n7 0.012
R9679 a_9206_4262.n29 a_9206_4262.n23 0.011
R9680 a_9206_4262.n30 a_9206_4262.n29 0.011
R9681 a_9206_4262.n14 a_9206_4262.n10 0.011
R9682 a_9206_4262.n38 a_9206_4262.n37 0.01
R9683 a_9206_4262.n22 a_9206_4262.n21 0.01
R9684 a_9206_4262.n21 a_9206_4262.n14 0.01
R9685 a_9206_4262.n37 a_9206_4262.n30 0.01
R9686 a_20166_11506.n10 a_20166_11506.t2 10.181
R9687 a_20166_11506.n10 a_20166_11506.t3 10.181
R9688 a_20166_11506.t0 a_20166_11506.n18 9.68
R9689 a_20166_11506.n1 a_20166_11506.n0 9.302
R9690 a_20166_11506.n7 a_20166_11506.n6 9.3
R9691 a_20166_11506.n5 a_20166_11506.n4 9.3
R9692 a_20166_11506.n9 a_20166_11506.n8 9
R9693 a_20166_11506.n13 a_20166_11506.n12 7.729
R9694 a_20166_11506.n13 a_20166_11506.n10 6.296
R9695 a_20166_11506.n16 a_20166_11506.n1 4.508
R9696 a_20166_11506.n15 a_20166_11506.n14 4.501
R9697 a_20166_11506.n15 a_20166_11506.n9 4.501
R9698 a_20166_11506.n16 a_20166_11506.n3 4.494
R9699 a_20166_11506.n18 a_20166_11506.t1 1.259
R9700 a_20166_11506.n12 a_20166_11506.n11 0.536
R9701 a_20166_11506.n18 a_20166_11506.n17 0.415
R9702 a_20166_11506.n14 a_20166_11506.n13 0.151
R9703 a_20166_11506.n7 a_20166_11506.n5 0.028
R9704 a_20166_11506.n3 a_20166_11506.n2 0.025
R9705 a_20166_11506.n17 a_20166_11506.n16 0.021
R9706 a_20166_11506.n9 a_20166_11506.n7 0.012
R9707 a_20166_11506.n16 a_20166_11506.n15 0.006
R9708 a_1416_6016.n10 a_1416_6016.t3 10.181
R9709 a_1416_6016.n10 a_1416_6016.t2 10.181
R9710 a_1416_6016.t1 a_1416_6016.n18 9.68
R9711 a_1416_6016.n1 a_1416_6016.n0 9.302
R9712 a_1416_6016.n7 a_1416_6016.n6 9.3
R9713 a_1416_6016.n5 a_1416_6016.n4 9.3
R9714 a_1416_6016.n9 a_1416_6016.n8 9
R9715 a_1416_6016.n13 a_1416_6016.n12 7.729
R9716 a_1416_6016.n13 a_1416_6016.n10 6.296
R9717 a_1416_6016.n16 a_1416_6016.n1 4.508
R9718 a_1416_6016.n15 a_1416_6016.n14 4.501
R9719 a_1416_6016.n15 a_1416_6016.n9 4.501
R9720 a_1416_6016.n16 a_1416_6016.n3 4.494
R9721 a_1416_6016.n18 a_1416_6016.t0 1.259
R9722 a_1416_6016.n12 a_1416_6016.n11 0.536
R9723 a_1416_6016.n18 a_1416_6016.n17 0.415
R9724 a_1416_6016.n14 a_1416_6016.n13 0.151
R9725 a_1416_6016.n7 a_1416_6016.n5 0.028
R9726 a_1416_6016.n3 a_1416_6016.n2 0.025
R9727 a_1416_6016.n17 a_1416_6016.n16 0.021
R9728 a_1416_6016.n9 a_1416_6016.n7 0.012
R9729 a_1416_6016.n16 a_1416_6016.n15 0.006
R9730 a_24206_2432.n26 a_24206_2432.t2 10.181
R9731 a_24206_2432.n18 a_24206_2432.t1 10.181
R9732 a_24206_2432.t0 a_24206_2432.n39 9.68
R9733 a_24206_2432.n3 a_24206_2432.n2 9.302
R9734 a_24206_2432.n13 a_24206_2432.n12 9.302
R9735 a_24206_2432.n32 a_24206_2432.n31 9.3
R9736 a_24206_2432.n34 a_24206_2432.n33 9.3
R9737 a_24206_2432.n7 a_24206_2432.n6 9.3
R9738 a_24206_2432.n5 a_24206_2432.n4 9.3
R9739 a_24206_2432.n36 a_24206_2432.n35 9
R9740 a_24206_2432.n9 a_24206_2432.n8 9
R9741 a_24206_2432.n27 a_24206_2432.n25 7.729
R9742 a_24206_2432.n19 a_24206_2432.n17 7.729
R9743 a_24206_2432.n27 a_24206_2432.n26 6.296
R9744 a_24206_2432.n19 a_24206_2432.n18 6.296
R9745 a_24206_2432.n30 a_24206_2432.n3 4.508
R9746 a_24206_2432.n14 a_24206_2432.n13 4.508
R9747 a_24206_2432.n37 a_24206_2432.n36 4.496
R9748 a_24206_2432.n21 a_24206_2432.n20 4.496
R9749 a_24206_2432.n29 a_24206_2432.n28 4.495
R9750 a_24206_2432.n10 a_24206_2432.n9 4.495
R9751 a_24206_2432.n14 a_24206_2432.n11 4.494
R9752 a_24206_2432.n30 a_24206_2432.n1 4.494
R9753 a_24206_2432.n39 a_24206_2432.t3 1.087
R9754 a_24206_2432.n25 a_24206_2432.n24 0.536
R9755 a_24206_2432.n17 a_24206_2432.n16 0.536
R9756 a_24206_2432.n39 a_24206_2432.n38 0.255
R9757 a_24206_2432.n28 a_24206_2432.n27 0.151
R9758 a_24206_2432.n20 a_24206_2432.n19 0.151
R9759 a_24206_2432.n23 a_24206_2432.n22 0.125
R9760 a_24206_2432.n34 a_24206_2432.n32 0.028
R9761 a_24206_2432.n7 a_24206_2432.n5 0.028
R9762 a_24206_2432.n1 a_24206_2432.n0 0.025
R9763 a_24206_2432.n20 a_24206_2432.n15 0.024
R9764 a_24206_2432.n36 a_24206_2432.n34 0.012
R9765 a_24206_2432.n9 a_24206_2432.n7 0.012
R9766 a_24206_2432.n29 a_24206_2432.n23 0.011
R9767 a_24206_2432.n30 a_24206_2432.n29 0.011
R9768 a_24206_2432.n14 a_24206_2432.n10 0.011
R9769 a_24206_2432.n38 a_24206_2432.n37 0.01
R9770 a_24206_2432.n22 a_24206_2432.n21 0.01
R9771 a_24206_2432.n21 a_24206_2432.n14 0.01
R9772 a_24206_2432.n37 a_24206_2432.n30 0.01
R9773 a_27956_9752.n26 a_27956_9752.t3 10.181
R9774 a_27956_9752.n18 a_27956_9752.t2 10.181
R9775 a_27956_9752.t0 a_27956_9752.n39 9.68
R9776 a_27956_9752.n3 a_27956_9752.n2 9.302
R9777 a_27956_9752.n13 a_27956_9752.n12 9.302
R9778 a_27956_9752.n32 a_27956_9752.n31 9.3
R9779 a_27956_9752.n34 a_27956_9752.n33 9.3
R9780 a_27956_9752.n7 a_27956_9752.n6 9.3
R9781 a_27956_9752.n5 a_27956_9752.n4 9.3
R9782 a_27956_9752.n36 a_27956_9752.n35 9
R9783 a_27956_9752.n9 a_27956_9752.n8 9
R9784 a_27956_9752.n27 a_27956_9752.n25 7.729
R9785 a_27956_9752.n19 a_27956_9752.n17 7.729
R9786 a_27956_9752.n27 a_27956_9752.n26 6.296
R9787 a_27956_9752.n19 a_27956_9752.n18 6.296
R9788 a_27956_9752.n30 a_27956_9752.n3 4.508
R9789 a_27956_9752.n14 a_27956_9752.n13 4.508
R9790 a_27956_9752.n37 a_27956_9752.n36 4.496
R9791 a_27956_9752.n21 a_27956_9752.n20 4.496
R9792 a_27956_9752.n29 a_27956_9752.n28 4.495
R9793 a_27956_9752.n10 a_27956_9752.n9 4.495
R9794 a_27956_9752.n14 a_27956_9752.n11 4.494
R9795 a_27956_9752.n30 a_27956_9752.n1 4.494
R9796 a_27956_9752.n39 a_27956_9752.t1 1.087
R9797 a_27956_9752.n25 a_27956_9752.n24 0.536
R9798 a_27956_9752.n17 a_27956_9752.n16 0.536
R9799 a_27956_9752.n39 a_27956_9752.n38 0.255
R9800 a_27956_9752.n28 a_27956_9752.n27 0.151
R9801 a_27956_9752.n20 a_27956_9752.n19 0.151
R9802 a_27956_9752.n23 a_27956_9752.n22 0.125
R9803 a_27956_9752.n34 a_27956_9752.n32 0.028
R9804 a_27956_9752.n7 a_27956_9752.n5 0.028
R9805 a_27956_9752.n1 a_27956_9752.n0 0.025
R9806 a_27956_9752.n20 a_27956_9752.n15 0.024
R9807 a_27956_9752.n36 a_27956_9752.n34 0.012
R9808 a_27956_9752.n9 a_27956_9752.n7 0.012
R9809 a_27956_9752.n29 a_27956_9752.n23 0.011
R9810 a_27956_9752.n30 a_27956_9752.n29 0.011
R9811 a_27956_9752.n14 a_27956_9752.n10 0.011
R9812 a_27956_9752.n38 a_27956_9752.n37 0.01
R9813 a_27956_9752.n22 a_27956_9752.n21 0.01
R9814 a_27956_9752.n21 a_27956_9752.n14 0.01
R9815 a_27956_9752.n37 a_27956_9752.n30 0.01
R9816 a_27666_9676.n10 a_27666_9676.t2 10.181
R9817 a_27666_9676.n10 a_27666_9676.t3 10.181
R9818 a_27666_9676.t0 a_27666_9676.n18 9.68
R9819 a_27666_9676.n1 a_27666_9676.n0 9.302
R9820 a_27666_9676.n7 a_27666_9676.n6 9.3
R9821 a_27666_9676.n5 a_27666_9676.n4 9.3
R9822 a_27666_9676.n9 a_27666_9676.n8 9
R9823 a_27666_9676.n13 a_27666_9676.n12 7.729
R9824 a_27666_9676.n13 a_27666_9676.n10 6.296
R9825 a_27666_9676.n16 a_27666_9676.n1 4.508
R9826 a_27666_9676.n15 a_27666_9676.n14 4.501
R9827 a_27666_9676.n15 a_27666_9676.n9 4.501
R9828 a_27666_9676.n16 a_27666_9676.n3 4.494
R9829 a_27666_9676.n18 a_27666_9676.t1 1.259
R9830 a_27666_9676.n12 a_27666_9676.n11 0.536
R9831 a_27666_9676.n18 a_27666_9676.n17 0.415
R9832 a_27666_9676.n14 a_27666_9676.n13 0.151
R9833 a_27666_9676.n7 a_27666_9676.n5 0.028
R9834 a_27666_9676.n3 a_27666_9676.n2 0.025
R9835 a_27666_9676.n17 a_27666_9676.n16 0.021
R9836 a_27666_9676.n9 a_27666_9676.n7 0.012
R9837 a_27666_9676.n16 a_27666_9676.n15 0.006
R9838 a_5456_6092.n26 a_5456_6092.t1 10.181
R9839 a_5456_6092.n18 a_5456_6092.t2 10.181
R9840 a_5456_6092.t0 a_5456_6092.n39 9.68
R9841 a_5456_6092.n3 a_5456_6092.n2 9.302
R9842 a_5456_6092.n13 a_5456_6092.n12 9.302
R9843 a_5456_6092.n32 a_5456_6092.n31 9.3
R9844 a_5456_6092.n34 a_5456_6092.n33 9.3
R9845 a_5456_6092.n7 a_5456_6092.n6 9.3
R9846 a_5456_6092.n5 a_5456_6092.n4 9.3
R9847 a_5456_6092.n36 a_5456_6092.n35 9
R9848 a_5456_6092.n9 a_5456_6092.n8 9
R9849 a_5456_6092.n27 a_5456_6092.n25 7.729
R9850 a_5456_6092.n19 a_5456_6092.n17 7.729
R9851 a_5456_6092.n27 a_5456_6092.n26 6.296
R9852 a_5456_6092.n19 a_5456_6092.n18 6.296
R9853 a_5456_6092.n30 a_5456_6092.n3 4.508
R9854 a_5456_6092.n14 a_5456_6092.n13 4.508
R9855 a_5456_6092.n37 a_5456_6092.n36 4.496
R9856 a_5456_6092.n21 a_5456_6092.n20 4.496
R9857 a_5456_6092.n29 a_5456_6092.n28 4.495
R9858 a_5456_6092.n10 a_5456_6092.n9 4.495
R9859 a_5456_6092.n14 a_5456_6092.n11 4.494
R9860 a_5456_6092.n30 a_5456_6092.n1 4.494
R9861 a_5456_6092.n39 a_5456_6092.t3 1.087
R9862 a_5456_6092.n25 a_5456_6092.n24 0.536
R9863 a_5456_6092.n17 a_5456_6092.n16 0.536
R9864 a_5456_6092.n39 a_5456_6092.n38 0.255
R9865 a_5456_6092.n28 a_5456_6092.n27 0.151
R9866 a_5456_6092.n20 a_5456_6092.n19 0.151
R9867 a_5456_6092.n23 a_5456_6092.n22 0.125
R9868 a_5456_6092.n34 a_5456_6092.n32 0.028
R9869 a_5456_6092.n7 a_5456_6092.n5 0.028
R9870 a_5456_6092.n1 a_5456_6092.n0 0.025
R9871 a_5456_6092.n20 a_5456_6092.n15 0.024
R9872 a_5456_6092.n36 a_5456_6092.n34 0.012
R9873 a_5456_6092.n9 a_5456_6092.n7 0.012
R9874 a_5456_6092.n29 a_5456_6092.n23 0.011
R9875 a_5456_6092.n30 a_5456_6092.n29 0.011
R9876 a_5456_6092.n14 a_5456_6092.n10 0.011
R9877 a_5456_6092.n38 a_5456_6092.n37 0.01
R9878 a_5456_6092.n22 a_5456_6092.n21 0.01
R9879 a_5456_6092.n21 a_5456_6092.n14 0.01
R9880 a_5456_6092.n37 a_5456_6092.n30 0.01
R9881 a_16416_7846.n10 a_16416_7846.t3 10.181
R9882 a_16416_7846.n10 a_16416_7846.t2 10.181
R9883 a_16416_7846.t1 a_16416_7846.n18 9.68
R9884 a_16416_7846.n1 a_16416_7846.n0 9.302
R9885 a_16416_7846.n7 a_16416_7846.n6 9.3
R9886 a_16416_7846.n5 a_16416_7846.n4 9.3
R9887 a_16416_7846.n9 a_16416_7846.n8 9
R9888 a_16416_7846.n13 a_16416_7846.n12 7.729
R9889 a_16416_7846.n13 a_16416_7846.n10 6.296
R9890 a_16416_7846.n16 a_16416_7846.n1 4.508
R9891 a_16416_7846.n15 a_16416_7846.n14 4.501
R9892 a_16416_7846.n15 a_16416_7846.n9 4.501
R9893 a_16416_7846.n16 a_16416_7846.n3 4.494
R9894 a_16416_7846.n18 a_16416_7846.t0 1.259
R9895 a_16416_7846.n12 a_16416_7846.n11 0.536
R9896 a_16416_7846.n18 a_16416_7846.n17 0.415
R9897 a_16416_7846.n14 a_16416_7846.n13 0.151
R9898 a_16416_7846.n7 a_16416_7846.n5 0.028
R9899 a_16416_7846.n3 a_16416_7846.n2 0.025
R9900 a_16416_7846.n17 a_16416_7846.n16 0.021
R9901 a_16416_7846.n9 a_16416_7846.n7 0.012
R9902 a_16416_7846.n16 a_16416_7846.n15 0.006
R9903 a_20166_6016.n10 a_20166_6016.t2 10.181
R9904 a_20166_6016.n10 a_20166_6016.t3 10.181
R9905 a_20166_6016.t1 a_20166_6016.n18 9.68
R9906 a_20166_6016.n1 a_20166_6016.n0 9.302
R9907 a_20166_6016.n7 a_20166_6016.n6 9.3
R9908 a_20166_6016.n5 a_20166_6016.n4 9.3
R9909 a_20166_6016.n9 a_20166_6016.n8 9
R9910 a_20166_6016.n13 a_20166_6016.n12 7.729
R9911 a_20166_6016.n13 a_20166_6016.n10 6.296
R9912 a_20166_6016.n16 a_20166_6016.n1 4.508
R9913 a_20166_6016.n15 a_20166_6016.n14 4.501
R9914 a_20166_6016.n15 a_20166_6016.n9 4.501
R9915 a_20166_6016.n16 a_20166_6016.n3 4.494
R9916 a_20166_6016.n18 a_20166_6016.t0 1.259
R9917 a_20166_6016.n12 a_20166_6016.n11 0.536
R9918 a_20166_6016.n18 a_20166_6016.n17 0.415
R9919 a_20166_6016.n14 a_20166_6016.n13 0.151
R9920 a_20166_6016.n7 a_20166_6016.n5 0.028
R9921 a_20166_6016.n3 a_20166_6016.n2 0.025
R9922 a_20166_6016.n17 a_20166_6016.n16 0.021
R9923 a_20166_6016.n9 a_20166_6016.n7 0.012
R9924 a_20166_6016.n16 a_20166_6016.n15 0.006
R9925 a_8916_13336.n10 a_8916_13336.t3 10.181
R9926 a_8916_13336.n10 a_8916_13336.t2 10.181
R9927 a_8916_13336.t0 a_8916_13336.n18 9.68
R9928 a_8916_13336.n1 a_8916_13336.n0 9.302
R9929 a_8916_13336.n7 a_8916_13336.n6 9.3
R9930 a_8916_13336.n5 a_8916_13336.n4 9.3
R9931 a_8916_13336.n9 a_8916_13336.n8 9
R9932 a_8916_13336.n13 a_8916_13336.n12 7.729
R9933 a_8916_13336.n13 a_8916_13336.n10 6.296
R9934 a_8916_13336.n16 a_8916_13336.n1 4.508
R9935 a_8916_13336.n15 a_8916_13336.n14 4.501
R9936 a_8916_13336.n15 a_8916_13336.n9 4.501
R9937 a_8916_13336.n16 a_8916_13336.n3 4.494
R9938 a_8916_13336.n18 a_8916_13336.t1 1.259
R9939 a_8916_13336.n12 a_8916_13336.n11 0.536
R9940 a_8916_13336.n18 a_8916_13336.n17 0.415
R9941 a_8916_13336.n14 a_8916_13336.n13 0.151
R9942 a_8916_13336.n7 a_8916_13336.n5 0.028
R9943 a_8916_13336.n3 a_8916_13336.n2 0.025
R9944 a_8916_13336.n17 a_8916_13336.n16 0.021
R9945 a_8916_13336.n9 a_8916_13336.n7 0.012
R9946 a_8916_13336.n16 a_8916_13336.n15 0.006
R9947 a_27956_6092.n26 a_27956_6092.t1 10.181
R9948 a_27956_6092.n18 a_27956_6092.t2 10.181
R9949 a_27956_6092.t0 a_27956_6092.n39 9.68
R9950 a_27956_6092.n3 a_27956_6092.n2 9.302
R9951 a_27956_6092.n13 a_27956_6092.n12 9.302
R9952 a_27956_6092.n32 a_27956_6092.n31 9.3
R9953 a_27956_6092.n34 a_27956_6092.n33 9.3
R9954 a_27956_6092.n7 a_27956_6092.n6 9.3
R9955 a_27956_6092.n5 a_27956_6092.n4 9.3
R9956 a_27956_6092.n36 a_27956_6092.n35 9
R9957 a_27956_6092.n9 a_27956_6092.n8 9
R9958 a_27956_6092.n27 a_27956_6092.n25 7.729
R9959 a_27956_6092.n19 a_27956_6092.n17 7.729
R9960 a_27956_6092.n27 a_27956_6092.n26 6.296
R9961 a_27956_6092.n19 a_27956_6092.n18 6.296
R9962 a_27956_6092.n30 a_27956_6092.n3 4.508
R9963 a_27956_6092.n14 a_27956_6092.n13 4.508
R9964 a_27956_6092.n37 a_27956_6092.n36 4.496
R9965 a_27956_6092.n21 a_27956_6092.n20 4.496
R9966 a_27956_6092.n29 a_27956_6092.n28 4.495
R9967 a_27956_6092.n10 a_27956_6092.n9 4.495
R9968 a_27956_6092.n14 a_27956_6092.n11 4.494
R9969 a_27956_6092.n30 a_27956_6092.n1 4.494
R9970 a_27956_6092.n39 a_27956_6092.t3 1.087
R9971 a_27956_6092.n25 a_27956_6092.n24 0.536
R9972 a_27956_6092.n17 a_27956_6092.n16 0.536
R9973 a_27956_6092.n39 a_27956_6092.n38 0.255
R9974 a_27956_6092.n28 a_27956_6092.n27 0.151
R9975 a_27956_6092.n20 a_27956_6092.n19 0.151
R9976 a_27956_6092.n23 a_27956_6092.n22 0.125
R9977 a_27956_6092.n34 a_27956_6092.n32 0.028
R9978 a_27956_6092.n7 a_27956_6092.n5 0.028
R9979 a_27956_6092.n1 a_27956_6092.n0 0.025
R9980 a_27956_6092.n20 a_27956_6092.n15 0.024
R9981 a_27956_6092.n36 a_27956_6092.n34 0.012
R9982 a_27956_6092.n9 a_27956_6092.n7 0.012
R9983 a_27956_6092.n29 a_27956_6092.n23 0.011
R9984 a_27956_6092.n30 a_27956_6092.n29 0.011
R9985 a_27956_6092.n14 a_27956_6092.n10 0.011
R9986 a_27956_6092.n38 a_27956_6092.n37 0.01
R9987 a_27956_6092.n22 a_27956_6092.n21 0.01
R9988 a_27956_6092.n21 a_27956_6092.n14 0.01
R9989 a_27956_6092.n37 a_27956_6092.n30 0.01
R9990 a_8916_4186.n10 a_8916_4186.t3 10.181
R9991 a_8916_4186.n10 a_8916_4186.t2 10.181
R9992 a_8916_4186.t0 a_8916_4186.n18 9.68
R9993 a_8916_4186.n1 a_8916_4186.n0 9.302
R9994 a_8916_4186.n7 a_8916_4186.n6 9.3
R9995 a_8916_4186.n5 a_8916_4186.n4 9.3
R9996 a_8916_4186.n9 a_8916_4186.n8 9
R9997 a_8916_4186.n13 a_8916_4186.n12 7.729
R9998 a_8916_4186.n13 a_8916_4186.n10 6.296
R9999 a_8916_4186.n16 a_8916_4186.n1 4.508
R10000 a_8916_4186.n15 a_8916_4186.n14 4.501
R10001 a_8916_4186.n15 a_8916_4186.n9 4.501
R10002 a_8916_4186.n16 a_8916_4186.n3 4.494
R10003 a_8916_4186.n18 a_8916_4186.t1 1.259
R10004 a_8916_4186.n12 a_8916_4186.n11 0.536
R10005 a_8916_4186.n18 a_8916_4186.n17 0.415
R10006 a_8916_4186.n14 a_8916_4186.n13 0.151
R10007 a_8916_4186.n7 a_8916_4186.n5 0.028
R10008 a_8916_4186.n3 a_8916_4186.n2 0.025
R10009 a_8916_4186.n17 a_8916_4186.n16 0.021
R10010 a_8916_4186.n9 a_8916_4186.n7 0.012
R10011 a_8916_4186.n16 a_8916_4186.n15 0.006
R10012 a_9206_11582.n26 a_9206_11582.t1 10.181
R10013 a_9206_11582.n18 a_9206_11582.t2 10.181
R10014 a_9206_11582.t0 a_9206_11582.n39 9.68
R10015 a_9206_11582.n3 a_9206_11582.n2 9.302
R10016 a_9206_11582.n13 a_9206_11582.n12 9.302
R10017 a_9206_11582.n32 a_9206_11582.n31 9.3
R10018 a_9206_11582.n34 a_9206_11582.n33 9.3
R10019 a_9206_11582.n7 a_9206_11582.n6 9.3
R10020 a_9206_11582.n5 a_9206_11582.n4 9.3
R10021 a_9206_11582.n36 a_9206_11582.n35 9
R10022 a_9206_11582.n9 a_9206_11582.n8 9
R10023 a_9206_11582.n27 a_9206_11582.n25 7.729
R10024 a_9206_11582.n19 a_9206_11582.n17 7.729
R10025 a_9206_11582.n27 a_9206_11582.n26 6.296
R10026 a_9206_11582.n19 a_9206_11582.n18 6.296
R10027 a_9206_11582.n30 a_9206_11582.n3 4.508
R10028 a_9206_11582.n14 a_9206_11582.n13 4.508
R10029 a_9206_11582.n37 a_9206_11582.n36 4.496
R10030 a_9206_11582.n21 a_9206_11582.n20 4.496
R10031 a_9206_11582.n29 a_9206_11582.n28 4.495
R10032 a_9206_11582.n10 a_9206_11582.n9 4.495
R10033 a_9206_11582.n14 a_9206_11582.n11 4.494
R10034 a_9206_11582.n30 a_9206_11582.n1 4.494
R10035 a_9206_11582.n39 a_9206_11582.t3 1.087
R10036 a_9206_11582.n25 a_9206_11582.n24 0.536
R10037 a_9206_11582.n17 a_9206_11582.n16 0.536
R10038 a_9206_11582.n39 a_9206_11582.n38 0.255
R10039 a_9206_11582.n28 a_9206_11582.n27 0.151
R10040 a_9206_11582.n20 a_9206_11582.n19 0.151
R10041 a_9206_11582.n23 a_9206_11582.n22 0.125
R10042 a_9206_11582.n34 a_9206_11582.n32 0.028
R10043 a_9206_11582.n7 a_9206_11582.n5 0.028
R10044 a_9206_11582.n1 a_9206_11582.n0 0.025
R10045 a_9206_11582.n20 a_9206_11582.n15 0.024
R10046 a_9206_11582.n36 a_9206_11582.n34 0.012
R10047 a_9206_11582.n9 a_9206_11582.n7 0.012
R10048 a_9206_11582.n29 a_9206_11582.n23 0.011
R10049 a_9206_11582.n30 a_9206_11582.n29 0.011
R10050 a_9206_11582.n14 a_9206_11582.n10 0.011
R10051 a_9206_11582.n38 a_9206_11582.n37 0.01
R10052 a_9206_11582.n22 a_9206_11582.n21 0.01
R10053 a_9206_11582.n21 a_9206_11582.n14 0.01
R10054 a_9206_11582.n37 a_9206_11582.n30 0.01
R10055 a_5166_11506.n10 a_5166_11506.t1 10.181
R10056 a_5166_11506.n10 a_5166_11506.t2 10.181
R10057 a_5166_11506.t3 a_5166_11506.n18 9.68
R10058 a_5166_11506.n1 a_5166_11506.n0 9.302
R10059 a_5166_11506.n7 a_5166_11506.n6 9.3
R10060 a_5166_11506.n5 a_5166_11506.n4 9.3
R10061 a_5166_11506.n9 a_5166_11506.n8 9
R10062 a_5166_11506.n13 a_5166_11506.n12 7.729
R10063 a_5166_11506.n13 a_5166_11506.n10 6.296
R10064 a_5166_11506.n16 a_5166_11506.n1 4.508
R10065 a_5166_11506.n15 a_5166_11506.n14 4.501
R10066 a_5166_11506.n15 a_5166_11506.n9 4.501
R10067 a_5166_11506.n16 a_5166_11506.n3 4.494
R10068 a_5166_11506.n18 a_5166_11506.t0 1.259
R10069 a_5166_11506.n12 a_5166_11506.n11 0.536
R10070 a_5166_11506.n18 a_5166_11506.n17 0.415
R10071 a_5166_11506.n14 a_5166_11506.n13 0.151
R10072 a_5166_11506.n7 a_5166_11506.n5 0.028
R10073 a_5166_11506.n3 a_5166_11506.n2 0.025
R10074 a_5166_11506.n17 a_5166_11506.n16 0.021
R10075 a_5166_11506.n9 a_5166_11506.n7 0.012
R10076 a_5166_11506.n16 a_5166_11506.n15 0.006
R10077 a_5456_11582.n26 a_5456_11582.t1 10.181
R10078 a_5456_11582.n18 a_5456_11582.t2 10.181
R10079 a_5456_11582.t0 a_5456_11582.n39 9.68
R10080 a_5456_11582.n3 a_5456_11582.n2 9.302
R10081 a_5456_11582.n13 a_5456_11582.n12 9.302
R10082 a_5456_11582.n32 a_5456_11582.n31 9.3
R10083 a_5456_11582.n34 a_5456_11582.n33 9.3
R10084 a_5456_11582.n7 a_5456_11582.n6 9.3
R10085 a_5456_11582.n5 a_5456_11582.n4 9.3
R10086 a_5456_11582.n36 a_5456_11582.n35 9
R10087 a_5456_11582.n9 a_5456_11582.n8 9
R10088 a_5456_11582.n27 a_5456_11582.n25 7.729
R10089 a_5456_11582.n19 a_5456_11582.n17 7.729
R10090 a_5456_11582.n27 a_5456_11582.n26 6.296
R10091 a_5456_11582.n19 a_5456_11582.n18 6.296
R10092 a_5456_11582.n30 a_5456_11582.n3 4.508
R10093 a_5456_11582.n14 a_5456_11582.n13 4.508
R10094 a_5456_11582.n37 a_5456_11582.n36 4.496
R10095 a_5456_11582.n21 a_5456_11582.n20 4.496
R10096 a_5456_11582.n29 a_5456_11582.n28 4.495
R10097 a_5456_11582.n10 a_5456_11582.n9 4.495
R10098 a_5456_11582.n14 a_5456_11582.n11 4.494
R10099 a_5456_11582.n30 a_5456_11582.n1 4.494
R10100 a_5456_11582.n39 a_5456_11582.t3 1.087
R10101 a_5456_11582.n25 a_5456_11582.n24 0.536
R10102 a_5456_11582.n17 a_5456_11582.n16 0.536
R10103 a_5456_11582.n39 a_5456_11582.n38 0.255
R10104 a_5456_11582.n28 a_5456_11582.n27 0.151
R10105 a_5456_11582.n20 a_5456_11582.n19 0.151
R10106 a_5456_11582.n23 a_5456_11582.n22 0.125
R10107 a_5456_11582.n34 a_5456_11582.n32 0.028
R10108 a_5456_11582.n7 a_5456_11582.n5 0.028
R10109 a_5456_11582.n1 a_5456_11582.n0 0.025
R10110 a_5456_11582.n20 a_5456_11582.n15 0.024
R10111 a_5456_11582.n36 a_5456_11582.n34 0.012
R10112 a_5456_11582.n9 a_5456_11582.n7 0.012
R10113 a_5456_11582.n29 a_5456_11582.n23 0.011
R10114 a_5456_11582.n30 a_5456_11582.n29 0.011
R10115 a_5456_11582.n14 a_5456_11582.n10 0.011
R10116 a_5456_11582.n38 a_5456_11582.n37 0.01
R10117 a_5456_11582.n22 a_5456_11582.n21 0.01
R10118 a_5456_11582.n21 a_5456_11582.n14 0.01
R10119 a_5456_11582.n37 a_5456_11582.n30 0.01
R10120 a_12956_9752.n26 a_12956_9752.t2 10.181
R10121 a_12956_9752.n18 a_12956_9752.t3 10.181
R10122 a_12956_9752.t0 a_12956_9752.n39 9.68
R10123 a_12956_9752.n3 a_12956_9752.n2 9.302
R10124 a_12956_9752.n13 a_12956_9752.n12 9.302
R10125 a_12956_9752.n32 a_12956_9752.n31 9.3
R10126 a_12956_9752.n34 a_12956_9752.n33 9.3
R10127 a_12956_9752.n7 a_12956_9752.n6 9.3
R10128 a_12956_9752.n5 a_12956_9752.n4 9.3
R10129 a_12956_9752.n36 a_12956_9752.n35 9
R10130 a_12956_9752.n9 a_12956_9752.n8 9
R10131 a_12956_9752.n27 a_12956_9752.n25 7.729
R10132 a_12956_9752.n19 a_12956_9752.n17 7.729
R10133 a_12956_9752.n27 a_12956_9752.n26 6.296
R10134 a_12956_9752.n19 a_12956_9752.n18 6.296
R10135 a_12956_9752.n30 a_12956_9752.n3 4.508
R10136 a_12956_9752.n14 a_12956_9752.n13 4.508
R10137 a_12956_9752.n37 a_12956_9752.n36 4.496
R10138 a_12956_9752.n21 a_12956_9752.n20 4.496
R10139 a_12956_9752.n29 a_12956_9752.n28 4.495
R10140 a_12956_9752.n10 a_12956_9752.n9 4.495
R10141 a_12956_9752.n14 a_12956_9752.n11 4.494
R10142 a_12956_9752.n30 a_12956_9752.n1 4.494
R10143 a_12956_9752.n39 a_12956_9752.t1 1.087
R10144 a_12956_9752.n25 a_12956_9752.n24 0.536
R10145 a_12956_9752.n17 a_12956_9752.n16 0.536
R10146 a_12956_9752.n39 a_12956_9752.n38 0.255
R10147 a_12956_9752.n28 a_12956_9752.n27 0.151
R10148 a_12956_9752.n20 a_12956_9752.n19 0.151
R10149 a_12956_9752.n23 a_12956_9752.n22 0.125
R10150 a_12956_9752.n34 a_12956_9752.n32 0.028
R10151 a_12956_9752.n7 a_12956_9752.n5 0.028
R10152 a_12956_9752.n1 a_12956_9752.n0 0.025
R10153 a_12956_9752.n20 a_12956_9752.n15 0.024
R10154 a_12956_9752.n36 a_12956_9752.n34 0.012
R10155 a_12956_9752.n9 a_12956_9752.n7 0.012
R10156 a_12956_9752.n29 a_12956_9752.n23 0.011
R10157 a_12956_9752.n30 a_12956_9752.n29 0.011
R10158 a_12956_9752.n14 a_12956_9752.n10 0.011
R10159 a_12956_9752.n38 a_12956_9752.n37 0.01
R10160 a_12956_9752.n22 a_12956_9752.n21 0.01
R10161 a_12956_9752.n21 a_12956_9752.n14 0.01
R10162 a_12956_9752.n37 a_12956_9752.n30 0.01
R10163 a_5166_15166.n10 a_5166_15166.t2 10.181
R10164 a_5166_15166.n10 a_5166_15166.t3 10.181
R10165 a_5166_15166.t0 a_5166_15166.n18 9.68
R10166 a_5166_15166.n1 a_5166_15166.n0 9.302
R10167 a_5166_15166.n7 a_5166_15166.n6 9.3
R10168 a_5166_15166.n5 a_5166_15166.n4 9.3
R10169 a_5166_15166.n9 a_5166_15166.n8 9
R10170 a_5166_15166.n13 a_5166_15166.n12 7.729
R10171 a_5166_15166.n13 a_5166_15166.n10 6.296
R10172 a_5166_15166.n16 a_5166_15166.n1 4.508
R10173 a_5166_15166.n15 a_5166_15166.n14 4.501
R10174 a_5166_15166.n15 a_5166_15166.n9 4.501
R10175 a_5166_15166.n16 a_5166_15166.n3 4.494
R10176 a_5166_15166.n18 a_5166_15166.t1 1.259
R10177 a_5166_15166.n12 a_5166_15166.n11 0.536
R10178 a_5166_15166.n18 a_5166_15166.n17 0.415
R10179 a_5166_15166.n14 a_5166_15166.n13 0.151
R10180 a_5166_15166.n7 a_5166_15166.n5 0.028
R10181 a_5166_15166.n3 a_5166_15166.n2 0.025
R10182 a_5166_15166.n17 a_5166_15166.n16 0.021
R10183 a_5166_15166.n9 a_5166_15166.n7 0.012
R10184 a_5166_15166.n16 a_5166_15166.n15 0.006
R10185 a_16416_11506.n10 a_16416_11506.t2 10.181
R10186 a_16416_11506.n10 a_16416_11506.t1 10.181
R10187 a_16416_11506.t3 a_16416_11506.n18 9.68
R10188 a_16416_11506.n1 a_16416_11506.n0 9.302
R10189 a_16416_11506.n7 a_16416_11506.n6 9.3
R10190 a_16416_11506.n5 a_16416_11506.n4 9.3
R10191 a_16416_11506.n9 a_16416_11506.n8 9
R10192 a_16416_11506.n13 a_16416_11506.n12 7.729
R10193 a_16416_11506.n13 a_16416_11506.n10 6.296
R10194 a_16416_11506.n16 a_16416_11506.n1 4.508
R10195 a_16416_11506.n15 a_16416_11506.n14 4.501
R10196 a_16416_11506.n15 a_16416_11506.n9 4.501
R10197 a_16416_11506.n16 a_16416_11506.n3 4.494
R10198 a_16416_11506.n18 a_16416_11506.t0 1.259
R10199 a_16416_11506.n12 a_16416_11506.n11 0.536
R10200 a_16416_11506.n18 a_16416_11506.n17 0.415
R10201 a_16416_11506.n14 a_16416_11506.n13 0.151
R10202 a_16416_11506.n7 a_16416_11506.n5 0.028
R10203 a_16416_11506.n3 a_16416_11506.n2 0.025
R10204 a_16416_11506.n17 a_16416_11506.n16 0.021
R10205 a_16416_11506.n9 a_16416_11506.n7 0.012
R10206 a_16416_11506.n16 a_16416_11506.n15 0.006
R10207 a_24206_9752.n26 a_24206_9752.t3 10.181
R10208 a_24206_9752.n18 a_24206_9752.t2 10.181
R10209 a_24206_9752.t0 a_24206_9752.n39 9.68
R10210 a_24206_9752.n3 a_24206_9752.n2 9.302
R10211 a_24206_9752.n13 a_24206_9752.n12 9.302
R10212 a_24206_9752.n32 a_24206_9752.n31 9.3
R10213 a_24206_9752.n34 a_24206_9752.n33 9.3
R10214 a_24206_9752.n7 a_24206_9752.n6 9.3
R10215 a_24206_9752.n5 a_24206_9752.n4 9.3
R10216 a_24206_9752.n36 a_24206_9752.n35 9
R10217 a_24206_9752.n9 a_24206_9752.n8 9
R10218 a_24206_9752.n27 a_24206_9752.n25 7.729
R10219 a_24206_9752.n19 a_24206_9752.n17 7.729
R10220 a_24206_9752.n27 a_24206_9752.n26 6.296
R10221 a_24206_9752.n19 a_24206_9752.n18 6.296
R10222 a_24206_9752.n30 a_24206_9752.n3 4.508
R10223 a_24206_9752.n14 a_24206_9752.n13 4.508
R10224 a_24206_9752.n37 a_24206_9752.n36 4.496
R10225 a_24206_9752.n21 a_24206_9752.n20 4.496
R10226 a_24206_9752.n29 a_24206_9752.n28 4.495
R10227 a_24206_9752.n10 a_24206_9752.n9 4.495
R10228 a_24206_9752.n14 a_24206_9752.n11 4.494
R10229 a_24206_9752.n30 a_24206_9752.n1 4.494
R10230 a_24206_9752.n39 a_24206_9752.t1 1.087
R10231 a_24206_9752.n25 a_24206_9752.n24 0.536
R10232 a_24206_9752.n17 a_24206_9752.n16 0.536
R10233 a_24206_9752.n39 a_24206_9752.n38 0.255
R10234 a_24206_9752.n28 a_24206_9752.n27 0.151
R10235 a_24206_9752.n20 a_24206_9752.n19 0.151
R10236 a_24206_9752.n23 a_24206_9752.n22 0.125
R10237 a_24206_9752.n34 a_24206_9752.n32 0.028
R10238 a_24206_9752.n7 a_24206_9752.n5 0.028
R10239 a_24206_9752.n1 a_24206_9752.n0 0.025
R10240 a_24206_9752.n20 a_24206_9752.n15 0.024
R10241 a_24206_9752.n36 a_24206_9752.n34 0.012
R10242 a_24206_9752.n9 a_24206_9752.n7 0.012
R10243 a_24206_9752.n29 a_24206_9752.n23 0.011
R10244 a_24206_9752.n30 a_24206_9752.n29 0.011
R10245 a_24206_9752.n14 a_24206_9752.n10 0.011
R10246 a_24206_9752.n38 a_24206_9752.n37 0.01
R10247 a_24206_9752.n22 a_24206_9752.n21 0.01
R10248 a_24206_9752.n21 a_24206_9752.n14 0.01
R10249 a_24206_9752.n37 a_24206_9752.n30 0.01
R10250 a_5166_7846.n10 a_5166_7846.t2 10.181
R10251 a_5166_7846.n10 a_5166_7846.t3 10.181
R10252 a_5166_7846.t0 a_5166_7846.n18 9.68
R10253 a_5166_7846.n1 a_5166_7846.n0 9.302
R10254 a_5166_7846.n7 a_5166_7846.n6 9.3
R10255 a_5166_7846.n5 a_5166_7846.n4 9.3
R10256 a_5166_7846.n9 a_5166_7846.n8 9
R10257 a_5166_7846.n13 a_5166_7846.n12 7.729
R10258 a_5166_7846.n13 a_5166_7846.n10 6.296
R10259 a_5166_7846.n16 a_5166_7846.n1 4.508
R10260 a_5166_7846.n15 a_5166_7846.n14 4.501
R10261 a_5166_7846.n15 a_5166_7846.n9 4.501
R10262 a_5166_7846.n16 a_5166_7846.n3 4.494
R10263 a_5166_7846.n18 a_5166_7846.t1 1.259
R10264 a_5166_7846.n12 a_5166_7846.n11 0.536
R10265 a_5166_7846.n18 a_5166_7846.n17 0.415
R10266 a_5166_7846.n14 a_5166_7846.n13 0.151
R10267 a_5166_7846.n7 a_5166_7846.n5 0.028
R10268 a_5166_7846.n3 a_5166_7846.n2 0.025
R10269 a_5166_7846.n17 a_5166_7846.n16 0.021
R10270 a_5166_7846.n9 a_5166_7846.n7 0.012
R10271 a_5166_7846.n16 a_5166_7846.n15 0.006
R10272 a_27956_4262.n26 a_27956_4262.t1 10.181
R10273 a_27956_4262.n18 a_27956_4262.t2 10.181
R10274 a_27956_4262.t0 a_27956_4262.n39 9.68
R10275 a_27956_4262.n3 a_27956_4262.n2 9.302
R10276 a_27956_4262.n13 a_27956_4262.n12 9.302
R10277 a_27956_4262.n32 a_27956_4262.n31 9.3
R10278 a_27956_4262.n34 a_27956_4262.n33 9.3
R10279 a_27956_4262.n7 a_27956_4262.n6 9.3
R10280 a_27956_4262.n5 a_27956_4262.n4 9.3
R10281 a_27956_4262.n36 a_27956_4262.n35 9
R10282 a_27956_4262.n9 a_27956_4262.n8 9
R10283 a_27956_4262.n27 a_27956_4262.n25 7.729
R10284 a_27956_4262.n19 a_27956_4262.n17 7.729
R10285 a_27956_4262.n27 a_27956_4262.n26 6.296
R10286 a_27956_4262.n19 a_27956_4262.n18 6.296
R10287 a_27956_4262.n30 a_27956_4262.n3 4.508
R10288 a_27956_4262.n14 a_27956_4262.n13 4.508
R10289 a_27956_4262.n37 a_27956_4262.n36 4.496
R10290 a_27956_4262.n21 a_27956_4262.n20 4.496
R10291 a_27956_4262.n29 a_27956_4262.n28 4.495
R10292 a_27956_4262.n10 a_27956_4262.n9 4.495
R10293 a_27956_4262.n14 a_27956_4262.n11 4.494
R10294 a_27956_4262.n30 a_27956_4262.n1 4.494
R10295 a_27956_4262.n39 a_27956_4262.t3 1.087
R10296 a_27956_4262.n25 a_27956_4262.n24 0.536
R10297 a_27956_4262.n17 a_27956_4262.n16 0.536
R10298 a_27956_4262.n39 a_27956_4262.n38 0.255
R10299 a_27956_4262.n28 a_27956_4262.n27 0.151
R10300 a_27956_4262.n20 a_27956_4262.n19 0.151
R10301 a_27956_4262.n23 a_27956_4262.n22 0.125
R10302 a_27956_4262.n34 a_27956_4262.n32 0.028
R10303 a_27956_4262.n7 a_27956_4262.n5 0.028
R10304 a_27956_4262.n1 a_27956_4262.n0 0.025
R10305 a_27956_4262.n20 a_27956_4262.n15 0.024
R10306 a_27956_4262.n36 a_27956_4262.n34 0.012
R10307 a_27956_4262.n9 a_27956_4262.n7 0.012
R10308 a_27956_4262.n29 a_27956_4262.n23 0.011
R10309 a_27956_4262.n30 a_27956_4262.n29 0.011
R10310 a_27956_4262.n14 a_27956_4262.n10 0.011
R10311 a_27956_4262.n38 a_27956_4262.n37 0.01
R10312 a_27956_4262.n22 a_27956_4262.n21 0.01
R10313 a_27956_4262.n21 a_27956_4262.n14 0.01
R10314 a_27956_4262.n37 a_27956_4262.n30 0.01
R10315 a_5166_526.n10 a_5166_526.t2 10.181
R10316 a_5166_526.n10 a_5166_526.t3 10.181
R10317 a_5166_526.t0 a_5166_526.n18 9.68
R10318 a_5166_526.n1 a_5166_526.n0 9.302
R10319 a_5166_526.n7 a_5166_526.n6 9.3
R10320 a_5166_526.n5 a_5166_526.n4 9.3
R10321 a_5166_526.n9 a_5166_526.n8 9
R10322 a_5166_526.n13 a_5166_526.n12 7.729
R10323 a_5166_526.n13 a_5166_526.n10 6.296
R10324 a_5166_526.n16 a_5166_526.n1 4.508
R10325 a_5166_526.n15 a_5166_526.n14 4.501
R10326 a_5166_526.n15 a_5166_526.n9 4.501
R10327 a_5166_526.n16 a_5166_526.n3 4.494
R10328 a_5166_526.n18 a_5166_526.t1 1.259
R10329 a_5166_526.n12 a_5166_526.n11 0.536
R10330 a_5166_526.n18 a_5166_526.n17 0.415
R10331 a_5166_526.n14 a_5166_526.n13 0.151
R10332 a_5166_526.n7 a_5166_526.n5 0.028
R10333 a_5166_526.n3 a_5166_526.n2 0.025
R10334 a_5166_526.n17 a_5166_526.n16 0.021
R10335 a_5166_526.n9 a_5166_526.n7 0.012
R10336 a_5166_526.n16 a_5166_526.n15 0.006
R10337 a_5166_9676.n10 a_5166_9676.t2 10.181
R10338 a_5166_9676.n10 a_5166_9676.t3 10.181
R10339 a_5166_9676.t0 a_5166_9676.n18 9.68
R10340 a_5166_9676.n1 a_5166_9676.n0 9.302
R10341 a_5166_9676.n7 a_5166_9676.n6 9.3
R10342 a_5166_9676.n5 a_5166_9676.n4 9.3
R10343 a_5166_9676.n9 a_5166_9676.n8 9
R10344 a_5166_9676.n13 a_5166_9676.n12 7.729
R10345 a_5166_9676.n13 a_5166_9676.n10 6.296
R10346 a_5166_9676.n16 a_5166_9676.n1 4.508
R10347 a_5166_9676.n15 a_5166_9676.n14 4.501
R10348 a_5166_9676.n15 a_5166_9676.n9 4.501
R10349 a_5166_9676.n16 a_5166_9676.n3 4.494
R10350 a_5166_9676.n18 a_5166_9676.t1 1.259
R10351 a_5166_9676.n12 a_5166_9676.n11 0.536
R10352 a_5166_9676.n18 a_5166_9676.n17 0.415
R10353 a_5166_9676.n14 a_5166_9676.n13 0.151
R10354 a_5166_9676.n7 a_5166_9676.n5 0.028
R10355 a_5166_9676.n3 a_5166_9676.n2 0.025
R10356 a_5166_9676.n17 a_5166_9676.n16 0.021
R10357 a_5166_9676.n9 a_5166_9676.n7 0.012
R10358 a_5166_9676.n16 a_5166_9676.n15 0.006
R10359 a_12666_9676.n10 a_12666_9676.t2 10.181
R10360 a_12666_9676.n10 a_12666_9676.t3 10.181
R10361 a_12666_9676.t1 a_12666_9676.n18 9.68
R10362 a_12666_9676.n1 a_12666_9676.n0 9.302
R10363 a_12666_9676.n7 a_12666_9676.n6 9.3
R10364 a_12666_9676.n5 a_12666_9676.n4 9.3
R10365 a_12666_9676.n9 a_12666_9676.n8 9
R10366 a_12666_9676.n13 a_12666_9676.n12 7.729
R10367 a_12666_9676.n13 a_12666_9676.n10 6.296
R10368 a_12666_9676.n16 a_12666_9676.n1 4.508
R10369 a_12666_9676.n15 a_12666_9676.n14 4.501
R10370 a_12666_9676.n15 a_12666_9676.n9 4.501
R10371 a_12666_9676.n16 a_12666_9676.n3 4.494
R10372 a_12666_9676.n18 a_12666_9676.t0 1.259
R10373 a_12666_9676.n12 a_12666_9676.n11 0.536
R10374 a_12666_9676.n18 a_12666_9676.n17 0.415
R10375 a_12666_9676.n14 a_12666_9676.n13 0.151
R10376 a_12666_9676.n7 a_12666_9676.n5 0.028
R10377 a_12666_9676.n3 a_12666_9676.n2 0.025
R10378 a_12666_9676.n17 a_12666_9676.n16 0.021
R10379 a_12666_9676.n9 a_12666_9676.n7 0.012
R10380 a_12666_9676.n16 a_12666_9676.n15 0.006
R10381 a_23916_9676.n10 a_23916_9676.t3 10.181
R10382 a_23916_9676.n10 a_23916_9676.t2 10.181
R10383 a_23916_9676.t0 a_23916_9676.n18 9.68
R10384 a_23916_9676.n1 a_23916_9676.n0 9.302
R10385 a_23916_9676.n7 a_23916_9676.n6 9.3
R10386 a_23916_9676.n5 a_23916_9676.n4 9.3
R10387 a_23916_9676.n9 a_23916_9676.n8 9
R10388 a_23916_9676.n13 a_23916_9676.n12 7.729
R10389 a_23916_9676.n13 a_23916_9676.n10 6.296
R10390 a_23916_9676.n16 a_23916_9676.n1 4.508
R10391 a_23916_9676.n15 a_23916_9676.n14 4.501
R10392 a_23916_9676.n15 a_23916_9676.n9 4.501
R10393 a_23916_9676.n16 a_23916_9676.n3 4.494
R10394 a_23916_9676.n18 a_23916_9676.t1 1.259
R10395 a_23916_9676.n12 a_23916_9676.n11 0.536
R10396 a_23916_9676.n18 a_23916_9676.n17 0.415
R10397 a_23916_9676.n14 a_23916_9676.n13 0.151
R10398 a_23916_9676.n7 a_23916_9676.n5 0.028
R10399 a_23916_9676.n3 a_23916_9676.n2 0.025
R10400 a_23916_9676.n17 a_23916_9676.n16 0.021
R10401 a_23916_9676.n9 a_23916_9676.n7 0.012
R10402 a_23916_9676.n16 a_23916_9676.n15 0.006
R10403 a_5166_4186.n10 a_5166_4186.t2 10.181
R10404 a_5166_4186.n10 a_5166_4186.t3 10.181
R10405 a_5166_4186.t0 a_5166_4186.n18 9.68
R10406 a_5166_4186.n1 a_5166_4186.n0 9.302
R10407 a_5166_4186.n7 a_5166_4186.n6 9.3
R10408 a_5166_4186.n5 a_5166_4186.n4 9.3
R10409 a_5166_4186.n9 a_5166_4186.n8 9
R10410 a_5166_4186.n13 a_5166_4186.n12 7.729
R10411 a_5166_4186.n13 a_5166_4186.n10 6.296
R10412 a_5166_4186.n16 a_5166_4186.n1 4.508
R10413 a_5166_4186.n15 a_5166_4186.n14 4.501
R10414 a_5166_4186.n15 a_5166_4186.n9 4.501
R10415 a_5166_4186.n16 a_5166_4186.n3 4.494
R10416 a_5166_4186.n18 a_5166_4186.t1 1.259
R10417 a_5166_4186.n12 a_5166_4186.n11 0.536
R10418 a_5166_4186.n18 a_5166_4186.n17 0.415
R10419 a_5166_4186.n14 a_5166_4186.n13 0.151
R10420 a_5166_4186.n7 a_5166_4186.n5 0.028
R10421 a_5166_4186.n3 a_5166_4186.n2 0.025
R10422 a_5166_4186.n17 a_5166_4186.n16 0.021
R10423 a_5166_4186.n9 a_5166_4186.n7 0.012
R10424 a_5166_4186.n16 a_5166_4186.n15 0.006
R10425 a_27956_602.n26 a_27956_602.t1 10.181
R10426 a_27956_602.n18 a_27956_602.t2 10.181
R10427 a_27956_602.t0 a_27956_602.n39 9.68
R10428 a_27956_602.n3 a_27956_602.n2 9.302
R10429 a_27956_602.n13 a_27956_602.n12 9.302
R10430 a_27956_602.n32 a_27956_602.n31 9.3
R10431 a_27956_602.n34 a_27956_602.n33 9.3
R10432 a_27956_602.n7 a_27956_602.n6 9.3
R10433 a_27956_602.n5 a_27956_602.n4 9.3
R10434 a_27956_602.n36 a_27956_602.n35 9
R10435 a_27956_602.n9 a_27956_602.n8 9
R10436 a_27956_602.n27 a_27956_602.n25 7.729
R10437 a_27956_602.n19 a_27956_602.n17 7.729
R10438 a_27956_602.n27 a_27956_602.n26 6.296
R10439 a_27956_602.n19 a_27956_602.n18 6.296
R10440 a_27956_602.n30 a_27956_602.n3 4.508
R10441 a_27956_602.n14 a_27956_602.n13 4.508
R10442 a_27956_602.n37 a_27956_602.n36 4.496
R10443 a_27956_602.n21 a_27956_602.n20 4.496
R10444 a_27956_602.n29 a_27956_602.n28 4.495
R10445 a_27956_602.n10 a_27956_602.n9 4.495
R10446 a_27956_602.n14 a_27956_602.n11 4.494
R10447 a_27956_602.n30 a_27956_602.n1 4.494
R10448 a_27956_602.n39 a_27956_602.t3 1.087
R10449 a_27956_602.n25 a_27956_602.n24 0.536
R10450 a_27956_602.n17 a_27956_602.n16 0.536
R10451 a_27956_602.n39 a_27956_602.n38 0.255
R10452 a_27956_602.n28 a_27956_602.n27 0.151
R10453 a_27956_602.n20 a_27956_602.n19 0.151
R10454 a_27956_602.n23 a_27956_602.n22 0.125
R10455 a_27956_602.n34 a_27956_602.n32 0.028
R10456 a_27956_602.n7 a_27956_602.n5 0.028
R10457 a_27956_602.n1 a_27956_602.n0 0.025
R10458 a_27956_602.n20 a_27956_602.n15 0.024
R10459 a_27956_602.n36 a_27956_602.n34 0.012
R10460 a_27956_602.n9 a_27956_602.n7 0.012
R10461 a_27956_602.n29 a_27956_602.n23 0.011
R10462 a_27956_602.n30 a_27956_602.n29 0.011
R10463 a_27956_602.n14 a_27956_602.n10 0.011
R10464 a_27956_602.n38 a_27956_602.n37 0.01
R10465 a_27956_602.n22 a_27956_602.n21 0.01
R10466 a_27956_602.n21 a_27956_602.n14 0.01
R10467 a_27956_602.n37 a_27956_602.n30 0.01
R10468 a_24206_6092.n26 a_24206_6092.t2 10.181
R10469 a_24206_6092.n18 a_24206_6092.t1 10.181
R10470 a_24206_6092.t0 a_24206_6092.n39 9.68
R10471 a_24206_6092.n3 a_24206_6092.n2 9.302
R10472 a_24206_6092.n13 a_24206_6092.n12 9.302
R10473 a_24206_6092.n32 a_24206_6092.n31 9.3
R10474 a_24206_6092.n34 a_24206_6092.n33 9.3
R10475 a_24206_6092.n7 a_24206_6092.n6 9.3
R10476 a_24206_6092.n5 a_24206_6092.n4 9.3
R10477 a_24206_6092.n36 a_24206_6092.n35 9
R10478 a_24206_6092.n9 a_24206_6092.n8 9
R10479 a_24206_6092.n27 a_24206_6092.n25 7.729
R10480 a_24206_6092.n19 a_24206_6092.n17 7.729
R10481 a_24206_6092.n27 a_24206_6092.n26 6.296
R10482 a_24206_6092.n19 a_24206_6092.n18 6.296
R10483 a_24206_6092.n30 a_24206_6092.n3 4.508
R10484 a_24206_6092.n14 a_24206_6092.n13 4.508
R10485 a_24206_6092.n37 a_24206_6092.n36 4.496
R10486 a_24206_6092.n21 a_24206_6092.n20 4.496
R10487 a_24206_6092.n29 a_24206_6092.n28 4.495
R10488 a_24206_6092.n10 a_24206_6092.n9 4.495
R10489 a_24206_6092.n14 a_24206_6092.n11 4.494
R10490 a_24206_6092.n30 a_24206_6092.n1 4.494
R10491 a_24206_6092.n39 a_24206_6092.t3 1.087
R10492 a_24206_6092.n25 a_24206_6092.n24 0.536
R10493 a_24206_6092.n17 a_24206_6092.n16 0.536
R10494 a_24206_6092.n39 a_24206_6092.n38 0.255
R10495 a_24206_6092.n28 a_24206_6092.n27 0.151
R10496 a_24206_6092.n20 a_24206_6092.n19 0.151
R10497 a_24206_6092.n23 a_24206_6092.n22 0.125
R10498 a_24206_6092.n34 a_24206_6092.n32 0.028
R10499 a_24206_6092.n7 a_24206_6092.n5 0.028
R10500 a_24206_6092.n1 a_24206_6092.n0 0.025
R10501 a_24206_6092.n20 a_24206_6092.n15 0.024
R10502 a_24206_6092.n36 a_24206_6092.n34 0.012
R10503 a_24206_6092.n9 a_24206_6092.n7 0.012
R10504 a_24206_6092.n29 a_24206_6092.n23 0.011
R10505 a_24206_6092.n30 a_24206_6092.n29 0.011
R10506 a_24206_6092.n14 a_24206_6092.n10 0.011
R10507 a_24206_6092.n38 a_24206_6092.n37 0.01
R10508 a_24206_6092.n22 a_24206_6092.n21 0.01
R10509 a_24206_6092.n21 a_24206_6092.n14 0.01
R10510 a_24206_6092.n37 a_24206_6092.n30 0.01
R10511 a_9206_7922.n26 a_9206_7922.t3 10.181
R10512 a_9206_7922.n18 a_9206_7922.t2 10.181
R10513 a_9206_7922.t0 a_9206_7922.n39 9.68
R10514 a_9206_7922.n3 a_9206_7922.n2 9.302
R10515 a_9206_7922.n13 a_9206_7922.n12 9.302
R10516 a_9206_7922.n32 a_9206_7922.n31 9.3
R10517 a_9206_7922.n34 a_9206_7922.n33 9.3
R10518 a_9206_7922.n7 a_9206_7922.n6 9.3
R10519 a_9206_7922.n5 a_9206_7922.n4 9.3
R10520 a_9206_7922.n36 a_9206_7922.n35 9
R10521 a_9206_7922.n9 a_9206_7922.n8 9
R10522 a_9206_7922.n27 a_9206_7922.n25 7.729
R10523 a_9206_7922.n19 a_9206_7922.n17 7.729
R10524 a_9206_7922.n27 a_9206_7922.n26 6.296
R10525 a_9206_7922.n19 a_9206_7922.n18 6.296
R10526 a_9206_7922.n30 a_9206_7922.n3 4.508
R10527 a_9206_7922.n14 a_9206_7922.n13 4.508
R10528 a_9206_7922.n37 a_9206_7922.n36 4.496
R10529 a_9206_7922.n21 a_9206_7922.n20 4.496
R10530 a_9206_7922.n29 a_9206_7922.n28 4.495
R10531 a_9206_7922.n10 a_9206_7922.n9 4.495
R10532 a_9206_7922.n14 a_9206_7922.n11 4.494
R10533 a_9206_7922.n30 a_9206_7922.n1 4.494
R10534 a_9206_7922.n39 a_9206_7922.t1 1.087
R10535 a_9206_7922.n25 a_9206_7922.n24 0.536
R10536 a_9206_7922.n17 a_9206_7922.n16 0.536
R10537 a_9206_7922.n39 a_9206_7922.n38 0.255
R10538 a_9206_7922.n28 a_9206_7922.n27 0.151
R10539 a_9206_7922.n20 a_9206_7922.n19 0.151
R10540 a_9206_7922.n23 a_9206_7922.n22 0.125
R10541 a_9206_7922.n34 a_9206_7922.n32 0.028
R10542 a_9206_7922.n7 a_9206_7922.n5 0.028
R10543 a_9206_7922.n1 a_9206_7922.n0 0.025
R10544 a_9206_7922.n20 a_9206_7922.n15 0.024
R10545 a_9206_7922.n36 a_9206_7922.n34 0.012
R10546 a_9206_7922.n9 a_9206_7922.n7 0.012
R10547 a_9206_7922.n29 a_9206_7922.n23 0.011
R10548 a_9206_7922.n30 a_9206_7922.n29 0.011
R10549 a_9206_7922.n14 a_9206_7922.n10 0.011
R10550 a_9206_7922.n38 a_9206_7922.n37 0.01
R10551 a_9206_7922.n22 a_9206_7922.n21 0.01
R10552 a_9206_7922.n21 a_9206_7922.n14 0.01
R10553 a_9206_7922.n37 a_9206_7922.n30 0.01
R10554 a_20456_2432.n26 a_20456_2432.t1 10.181
R10555 a_20456_2432.n18 a_20456_2432.t2 10.181
R10556 a_20456_2432.t0 a_20456_2432.n39 9.68
R10557 a_20456_2432.n3 a_20456_2432.n2 9.302
R10558 a_20456_2432.n13 a_20456_2432.n12 9.302
R10559 a_20456_2432.n32 a_20456_2432.n31 9.3
R10560 a_20456_2432.n34 a_20456_2432.n33 9.3
R10561 a_20456_2432.n7 a_20456_2432.n6 9.3
R10562 a_20456_2432.n5 a_20456_2432.n4 9.3
R10563 a_20456_2432.n36 a_20456_2432.n35 9
R10564 a_20456_2432.n9 a_20456_2432.n8 9
R10565 a_20456_2432.n27 a_20456_2432.n25 7.729
R10566 a_20456_2432.n19 a_20456_2432.n17 7.729
R10567 a_20456_2432.n27 a_20456_2432.n26 6.296
R10568 a_20456_2432.n19 a_20456_2432.n18 6.296
R10569 a_20456_2432.n30 a_20456_2432.n3 4.508
R10570 a_20456_2432.n14 a_20456_2432.n13 4.508
R10571 a_20456_2432.n37 a_20456_2432.n36 4.496
R10572 a_20456_2432.n21 a_20456_2432.n20 4.496
R10573 a_20456_2432.n29 a_20456_2432.n28 4.495
R10574 a_20456_2432.n10 a_20456_2432.n9 4.495
R10575 a_20456_2432.n14 a_20456_2432.n11 4.494
R10576 a_20456_2432.n30 a_20456_2432.n1 4.494
R10577 a_20456_2432.n39 a_20456_2432.t3 1.087
R10578 a_20456_2432.n25 a_20456_2432.n24 0.536
R10579 a_20456_2432.n17 a_20456_2432.n16 0.536
R10580 a_20456_2432.n39 a_20456_2432.n38 0.255
R10581 a_20456_2432.n28 a_20456_2432.n27 0.151
R10582 a_20456_2432.n20 a_20456_2432.n19 0.151
R10583 a_20456_2432.n23 a_20456_2432.n22 0.125
R10584 a_20456_2432.n34 a_20456_2432.n32 0.028
R10585 a_20456_2432.n7 a_20456_2432.n5 0.028
R10586 a_20456_2432.n1 a_20456_2432.n0 0.025
R10587 a_20456_2432.n20 a_20456_2432.n15 0.024
R10588 a_20456_2432.n36 a_20456_2432.n34 0.012
R10589 a_20456_2432.n9 a_20456_2432.n7 0.012
R10590 a_20456_2432.n29 a_20456_2432.n23 0.011
R10591 a_20456_2432.n30 a_20456_2432.n29 0.011
R10592 a_20456_2432.n14 a_20456_2432.n10 0.011
R10593 a_20456_2432.n38 a_20456_2432.n37 0.01
R10594 a_20456_2432.n22 a_20456_2432.n21 0.01
R10595 a_20456_2432.n21 a_20456_2432.n14 0.01
R10596 a_20456_2432.n37 a_20456_2432.n30 0.01
R10597 a_12956_2432.n26 a_12956_2432.t1 10.181
R10598 a_12956_2432.n18 a_12956_2432.t2 10.181
R10599 a_12956_2432.t0 a_12956_2432.n39 9.68
R10600 a_12956_2432.n3 a_12956_2432.n2 9.302
R10601 a_12956_2432.n13 a_12956_2432.n12 9.302
R10602 a_12956_2432.n32 a_12956_2432.n31 9.3
R10603 a_12956_2432.n34 a_12956_2432.n33 9.3
R10604 a_12956_2432.n7 a_12956_2432.n6 9.3
R10605 a_12956_2432.n5 a_12956_2432.n4 9.3
R10606 a_12956_2432.n36 a_12956_2432.n35 9
R10607 a_12956_2432.n9 a_12956_2432.n8 9
R10608 a_12956_2432.n27 a_12956_2432.n25 7.729
R10609 a_12956_2432.n19 a_12956_2432.n17 7.729
R10610 a_12956_2432.n27 a_12956_2432.n26 6.296
R10611 a_12956_2432.n19 a_12956_2432.n18 6.296
R10612 a_12956_2432.n30 a_12956_2432.n3 4.508
R10613 a_12956_2432.n14 a_12956_2432.n13 4.508
R10614 a_12956_2432.n37 a_12956_2432.n36 4.496
R10615 a_12956_2432.n21 a_12956_2432.n20 4.496
R10616 a_12956_2432.n29 a_12956_2432.n28 4.495
R10617 a_12956_2432.n10 a_12956_2432.n9 4.495
R10618 a_12956_2432.n14 a_12956_2432.n11 4.494
R10619 a_12956_2432.n30 a_12956_2432.n1 4.494
R10620 a_12956_2432.n39 a_12956_2432.t3 1.087
R10621 a_12956_2432.n25 a_12956_2432.n24 0.536
R10622 a_12956_2432.n17 a_12956_2432.n16 0.536
R10623 a_12956_2432.n39 a_12956_2432.n38 0.255
R10624 a_12956_2432.n28 a_12956_2432.n27 0.151
R10625 a_12956_2432.n20 a_12956_2432.n19 0.151
R10626 a_12956_2432.n23 a_12956_2432.n22 0.125
R10627 a_12956_2432.n34 a_12956_2432.n32 0.028
R10628 a_12956_2432.n7 a_12956_2432.n5 0.028
R10629 a_12956_2432.n1 a_12956_2432.n0 0.025
R10630 a_12956_2432.n20 a_12956_2432.n15 0.024
R10631 a_12956_2432.n36 a_12956_2432.n34 0.012
R10632 a_12956_2432.n9 a_12956_2432.n7 0.012
R10633 a_12956_2432.n29 a_12956_2432.n23 0.011
R10634 a_12956_2432.n30 a_12956_2432.n29 0.011
R10635 a_12956_2432.n14 a_12956_2432.n10 0.011
R10636 a_12956_2432.n38 a_12956_2432.n37 0.01
R10637 a_12956_2432.n22 a_12956_2432.n21 0.01
R10638 a_12956_2432.n21 a_12956_2432.n14 0.01
R10639 a_12956_2432.n37 a_12956_2432.n30 0.01
R10640 a_27666_4186.n10 a_27666_4186.t2 10.181
R10641 a_27666_4186.n10 a_27666_4186.t3 10.181
R10642 a_27666_4186.t0 a_27666_4186.n18 9.68
R10643 a_27666_4186.n1 a_27666_4186.n0 9.302
R10644 a_27666_4186.n7 a_27666_4186.n6 9.3
R10645 a_27666_4186.n5 a_27666_4186.n4 9.3
R10646 a_27666_4186.n9 a_27666_4186.n8 9
R10647 a_27666_4186.n13 a_27666_4186.n12 7.729
R10648 a_27666_4186.n13 a_27666_4186.n10 6.296
R10649 a_27666_4186.n16 a_27666_4186.n1 4.508
R10650 a_27666_4186.n15 a_27666_4186.n14 4.501
R10651 a_27666_4186.n15 a_27666_4186.n9 4.501
R10652 a_27666_4186.n16 a_27666_4186.n3 4.494
R10653 a_27666_4186.n18 a_27666_4186.t1 1.259
R10654 a_27666_4186.n12 a_27666_4186.n11 0.536
R10655 a_27666_4186.n18 a_27666_4186.n17 0.415
R10656 a_27666_4186.n14 a_27666_4186.n13 0.151
R10657 a_27666_4186.n7 a_27666_4186.n5 0.028
R10658 a_27666_4186.n3 a_27666_4186.n2 0.025
R10659 a_27666_4186.n17 a_27666_4186.n16 0.021
R10660 a_27666_4186.n9 a_27666_4186.n7 0.012
R10661 a_27666_4186.n16 a_27666_4186.n15 0.006
R10662 a_20456_6092.n26 a_20456_6092.t1 10.181
R10663 a_20456_6092.n18 a_20456_6092.t2 10.181
R10664 a_20456_6092.t0 a_20456_6092.n39 9.68
R10665 a_20456_6092.n3 a_20456_6092.n2 9.302
R10666 a_20456_6092.n13 a_20456_6092.n12 9.302
R10667 a_20456_6092.n32 a_20456_6092.n31 9.3
R10668 a_20456_6092.n34 a_20456_6092.n33 9.3
R10669 a_20456_6092.n7 a_20456_6092.n6 9.3
R10670 a_20456_6092.n5 a_20456_6092.n4 9.3
R10671 a_20456_6092.n36 a_20456_6092.n35 9
R10672 a_20456_6092.n9 a_20456_6092.n8 9
R10673 a_20456_6092.n27 a_20456_6092.n25 7.729
R10674 a_20456_6092.n19 a_20456_6092.n17 7.729
R10675 a_20456_6092.n27 a_20456_6092.n26 6.296
R10676 a_20456_6092.n19 a_20456_6092.n18 6.296
R10677 a_20456_6092.n30 a_20456_6092.n3 4.508
R10678 a_20456_6092.n14 a_20456_6092.n13 4.508
R10679 a_20456_6092.n37 a_20456_6092.n36 4.496
R10680 a_20456_6092.n21 a_20456_6092.n20 4.496
R10681 a_20456_6092.n29 a_20456_6092.n28 4.495
R10682 a_20456_6092.n10 a_20456_6092.n9 4.495
R10683 a_20456_6092.n14 a_20456_6092.n11 4.494
R10684 a_20456_6092.n30 a_20456_6092.n1 4.494
R10685 a_20456_6092.n39 a_20456_6092.t3 1.087
R10686 a_20456_6092.n25 a_20456_6092.n24 0.536
R10687 a_20456_6092.n17 a_20456_6092.n16 0.536
R10688 a_20456_6092.n39 a_20456_6092.n38 0.255
R10689 a_20456_6092.n28 a_20456_6092.n27 0.151
R10690 a_20456_6092.n20 a_20456_6092.n19 0.151
R10691 a_20456_6092.n23 a_20456_6092.n22 0.125
R10692 a_20456_6092.n34 a_20456_6092.n32 0.028
R10693 a_20456_6092.n7 a_20456_6092.n5 0.028
R10694 a_20456_6092.n1 a_20456_6092.n0 0.025
R10695 a_20456_6092.n20 a_20456_6092.n15 0.024
R10696 a_20456_6092.n36 a_20456_6092.n34 0.012
R10697 a_20456_6092.n9 a_20456_6092.n7 0.012
R10698 a_20456_6092.n29 a_20456_6092.n23 0.011
R10699 a_20456_6092.n30 a_20456_6092.n29 0.011
R10700 a_20456_6092.n14 a_20456_6092.n10 0.011
R10701 a_20456_6092.n38 a_20456_6092.n37 0.01
R10702 a_20456_6092.n22 a_20456_6092.n21 0.01
R10703 a_20456_6092.n21 a_20456_6092.n14 0.01
R10704 a_20456_6092.n37 a_20456_6092.n30 0.01
R10705 a_27956_7922.n26 a_27956_7922.t2 10.181
R10706 a_27956_7922.n18 a_27956_7922.t3 10.181
R10707 a_27956_7922.t0 a_27956_7922.n39 9.68
R10708 a_27956_7922.n3 a_27956_7922.n2 9.302
R10709 a_27956_7922.n13 a_27956_7922.n12 9.302
R10710 a_27956_7922.n32 a_27956_7922.n31 9.3
R10711 a_27956_7922.n34 a_27956_7922.n33 9.3
R10712 a_27956_7922.n7 a_27956_7922.n6 9.3
R10713 a_27956_7922.n5 a_27956_7922.n4 9.3
R10714 a_27956_7922.n36 a_27956_7922.n35 9
R10715 a_27956_7922.n9 a_27956_7922.n8 9
R10716 a_27956_7922.n27 a_27956_7922.n25 7.729
R10717 a_27956_7922.n19 a_27956_7922.n17 7.729
R10718 a_27956_7922.n27 a_27956_7922.n26 6.296
R10719 a_27956_7922.n19 a_27956_7922.n18 6.296
R10720 a_27956_7922.n30 a_27956_7922.n3 4.508
R10721 a_27956_7922.n14 a_27956_7922.n13 4.508
R10722 a_27956_7922.n37 a_27956_7922.n36 4.496
R10723 a_27956_7922.n21 a_27956_7922.n20 4.496
R10724 a_27956_7922.n29 a_27956_7922.n28 4.495
R10725 a_27956_7922.n10 a_27956_7922.n9 4.495
R10726 a_27956_7922.n14 a_27956_7922.n11 4.494
R10727 a_27956_7922.n30 a_27956_7922.n1 4.494
R10728 a_27956_7922.n39 a_27956_7922.t1 1.087
R10729 a_27956_7922.n25 a_27956_7922.n24 0.536
R10730 a_27956_7922.n17 a_27956_7922.n16 0.536
R10731 a_27956_7922.n39 a_27956_7922.n38 0.255
R10732 a_27956_7922.n28 a_27956_7922.n27 0.151
R10733 a_27956_7922.n20 a_27956_7922.n19 0.151
R10734 a_27956_7922.n23 a_27956_7922.n22 0.125
R10735 a_27956_7922.n34 a_27956_7922.n32 0.028
R10736 a_27956_7922.n7 a_27956_7922.n5 0.028
R10737 a_27956_7922.n1 a_27956_7922.n0 0.025
R10738 a_27956_7922.n20 a_27956_7922.n15 0.024
R10739 a_27956_7922.n36 a_27956_7922.n34 0.012
R10740 a_27956_7922.n9 a_27956_7922.n7 0.012
R10741 a_27956_7922.n29 a_27956_7922.n23 0.011
R10742 a_27956_7922.n30 a_27956_7922.n29 0.011
R10743 a_27956_7922.n14 a_27956_7922.n10 0.011
R10744 a_27956_7922.n38 a_27956_7922.n37 0.01
R10745 a_27956_7922.n22 a_27956_7922.n21 0.01
R10746 a_27956_7922.n21 a_27956_7922.n14 0.01
R10747 a_27956_7922.n37 a_27956_7922.n30 0.01
R10748 a_1706_9752.n26 a_1706_9752.t3 10.181
R10749 a_1706_9752.n18 a_1706_9752.t2 10.181
R10750 a_1706_9752.t0 a_1706_9752.n39 9.68
R10751 a_1706_9752.n3 a_1706_9752.n2 9.302
R10752 a_1706_9752.n13 a_1706_9752.n12 9.302
R10753 a_1706_9752.n32 a_1706_9752.n31 9.3
R10754 a_1706_9752.n34 a_1706_9752.n33 9.3
R10755 a_1706_9752.n7 a_1706_9752.n6 9.3
R10756 a_1706_9752.n5 a_1706_9752.n4 9.3
R10757 a_1706_9752.n36 a_1706_9752.n35 9
R10758 a_1706_9752.n9 a_1706_9752.n8 9
R10759 a_1706_9752.n27 a_1706_9752.n25 7.729
R10760 a_1706_9752.n19 a_1706_9752.n17 7.729
R10761 a_1706_9752.n27 a_1706_9752.n26 6.296
R10762 a_1706_9752.n19 a_1706_9752.n18 6.296
R10763 a_1706_9752.n30 a_1706_9752.n3 4.508
R10764 a_1706_9752.n14 a_1706_9752.n13 4.508
R10765 a_1706_9752.n37 a_1706_9752.n36 4.496
R10766 a_1706_9752.n21 a_1706_9752.n20 4.496
R10767 a_1706_9752.n29 a_1706_9752.n28 4.495
R10768 a_1706_9752.n10 a_1706_9752.n9 4.495
R10769 a_1706_9752.n14 a_1706_9752.n11 4.494
R10770 a_1706_9752.n30 a_1706_9752.n1 4.494
R10771 a_1706_9752.n39 a_1706_9752.t1 1.087
R10772 a_1706_9752.n25 a_1706_9752.n24 0.536
R10773 a_1706_9752.n17 a_1706_9752.n16 0.536
R10774 a_1706_9752.n39 a_1706_9752.n38 0.255
R10775 a_1706_9752.n28 a_1706_9752.n27 0.151
R10776 a_1706_9752.n20 a_1706_9752.n19 0.151
R10777 a_1706_9752.n23 a_1706_9752.n22 0.125
R10778 a_1706_9752.n34 a_1706_9752.n32 0.028
R10779 a_1706_9752.n7 a_1706_9752.n5 0.028
R10780 a_1706_9752.n1 a_1706_9752.n0 0.025
R10781 a_1706_9752.n20 a_1706_9752.n15 0.024
R10782 a_1706_9752.n36 a_1706_9752.n34 0.012
R10783 a_1706_9752.n9 a_1706_9752.n7 0.012
R10784 a_1706_9752.n29 a_1706_9752.n23 0.011
R10785 a_1706_9752.n30 a_1706_9752.n29 0.011
R10786 a_1706_9752.n14 a_1706_9752.n10 0.011
R10787 a_1706_9752.n38 a_1706_9752.n37 0.01
R10788 a_1706_9752.n22 a_1706_9752.n21 0.01
R10789 a_1706_9752.n21 a_1706_9752.n14 0.01
R10790 a_1706_9752.n37 a_1706_9752.n30 0.01
R10791 a_5456_4262.n26 a_5456_4262.t1 10.181
R10792 a_5456_4262.n18 a_5456_4262.t2 10.181
R10793 a_5456_4262.t0 a_5456_4262.n39 9.68
R10794 a_5456_4262.n3 a_5456_4262.n2 9.302
R10795 a_5456_4262.n13 a_5456_4262.n12 9.302
R10796 a_5456_4262.n32 a_5456_4262.n31 9.3
R10797 a_5456_4262.n34 a_5456_4262.n33 9.3
R10798 a_5456_4262.n7 a_5456_4262.n6 9.3
R10799 a_5456_4262.n5 a_5456_4262.n4 9.3
R10800 a_5456_4262.n36 a_5456_4262.n35 9
R10801 a_5456_4262.n9 a_5456_4262.n8 9
R10802 a_5456_4262.n27 a_5456_4262.n25 7.729
R10803 a_5456_4262.n19 a_5456_4262.n17 7.729
R10804 a_5456_4262.n27 a_5456_4262.n26 6.296
R10805 a_5456_4262.n19 a_5456_4262.n18 6.296
R10806 a_5456_4262.n30 a_5456_4262.n3 4.508
R10807 a_5456_4262.n14 a_5456_4262.n13 4.508
R10808 a_5456_4262.n37 a_5456_4262.n36 4.496
R10809 a_5456_4262.n21 a_5456_4262.n20 4.496
R10810 a_5456_4262.n29 a_5456_4262.n28 4.495
R10811 a_5456_4262.n10 a_5456_4262.n9 4.495
R10812 a_5456_4262.n14 a_5456_4262.n11 4.494
R10813 a_5456_4262.n30 a_5456_4262.n1 4.494
R10814 a_5456_4262.n39 a_5456_4262.t3 1.087
R10815 a_5456_4262.n25 a_5456_4262.n24 0.536
R10816 a_5456_4262.n17 a_5456_4262.n16 0.536
R10817 a_5456_4262.n39 a_5456_4262.n38 0.255
R10818 a_5456_4262.n28 a_5456_4262.n27 0.151
R10819 a_5456_4262.n20 a_5456_4262.n19 0.151
R10820 a_5456_4262.n23 a_5456_4262.n22 0.125
R10821 a_5456_4262.n34 a_5456_4262.n32 0.028
R10822 a_5456_4262.n7 a_5456_4262.n5 0.028
R10823 a_5456_4262.n1 a_5456_4262.n0 0.025
R10824 a_5456_4262.n20 a_5456_4262.n15 0.024
R10825 a_5456_4262.n36 a_5456_4262.n34 0.012
R10826 a_5456_4262.n9 a_5456_4262.n7 0.012
R10827 a_5456_4262.n29 a_5456_4262.n23 0.011
R10828 a_5456_4262.n30 a_5456_4262.n29 0.011
R10829 a_5456_4262.n14 a_5456_4262.n10 0.011
R10830 a_5456_4262.n38 a_5456_4262.n37 0.01
R10831 a_5456_4262.n22 a_5456_4262.n21 0.01
R10832 a_5456_4262.n21 a_5456_4262.n14 0.01
R10833 a_5456_4262.n37 a_5456_4262.n30 0.01
R10834 a_12956_6092.n26 a_12956_6092.t1 10.181
R10835 a_12956_6092.n18 a_12956_6092.t2 10.181
R10836 a_12956_6092.t0 a_12956_6092.n39 9.68
R10837 a_12956_6092.n3 a_12956_6092.n2 9.302
R10838 a_12956_6092.n13 a_12956_6092.n12 9.302
R10839 a_12956_6092.n32 a_12956_6092.n31 9.3
R10840 a_12956_6092.n34 a_12956_6092.n33 9.3
R10841 a_12956_6092.n7 a_12956_6092.n6 9.3
R10842 a_12956_6092.n5 a_12956_6092.n4 9.3
R10843 a_12956_6092.n36 a_12956_6092.n35 9
R10844 a_12956_6092.n9 a_12956_6092.n8 9
R10845 a_12956_6092.n27 a_12956_6092.n25 7.729
R10846 a_12956_6092.n19 a_12956_6092.n17 7.729
R10847 a_12956_6092.n27 a_12956_6092.n26 6.296
R10848 a_12956_6092.n19 a_12956_6092.n18 6.296
R10849 a_12956_6092.n30 a_12956_6092.n3 4.508
R10850 a_12956_6092.n14 a_12956_6092.n13 4.508
R10851 a_12956_6092.n37 a_12956_6092.n36 4.496
R10852 a_12956_6092.n21 a_12956_6092.n20 4.496
R10853 a_12956_6092.n29 a_12956_6092.n28 4.495
R10854 a_12956_6092.n10 a_12956_6092.n9 4.495
R10855 a_12956_6092.n14 a_12956_6092.n11 4.494
R10856 a_12956_6092.n30 a_12956_6092.n1 4.494
R10857 a_12956_6092.n39 a_12956_6092.t3 1.087
R10858 a_12956_6092.n25 a_12956_6092.n24 0.536
R10859 a_12956_6092.n17 a_12956_6092.n16 0.536
R10860 a_12956_6092.n39 a_12956_6092.n38 0.255
R10861 a_12956_6092.n28 a_12956_6092.n27 0.151
R10862 a_12956_6092.n20 a_12956_6092.n19 0.151
R10863 a_12956_6092.n23 a_12956_6092.n22 0.125
R10864 a_12956_6092.n34 a_12956_6092.n32 0.028
R10865 a_12956_6092.n7 a_12956_6092.n5 0.028
R10866 a_12956_6092.n1 a_12956_6092.n0 0.025
R10867 a_12956_6092.n20 a_12956_6092.n15 0.024
R10868 a_12956_6092.n36 a_12956_6092.n34 0.012
R10869 a_12956_6092.n9 a_12956_6092.n7 0.012
R10870 a_12956_6092.n29 a_12956_6092.n23 0.011
R10871 a_12956_6092.n30 a_12956_6092.n29 0.011
R10872 a_12956_6092.n14 a_12956_6092.n10 0.011
R10873 a_12956_6092.n38 a_12956_6092.n37 0.01
R10874 a_12956_6092.n22 a_12956_6092.n21 0.01
R10875 a_12956_6092.n21 a_12956_6092.n14 0.01
R10876 a_12956_6092.n37 a_12956_6092.n30 0.01
C21 OUT_P GND 62.01fF
C22 OUT_N GND 61.96fF
C23 bit5 GND 83.52fF
C24 bit4 GND 41.96fF
C25 bit3 GND 21.31fF
C26 bit2 GND 19.73fF
C27 bit1 GND 18.74fF
C28 bit0 GND 18.18fF
C29 VDD GND 12.62fF
C30 a_12956_6092.n0 GND 0.00fF
C31 a_12956_6092.n1 GND 0.00fF
C32 a_12956_6092.n2 GND 0.01fF
C33 a_12956_6092.n3 GND 0.01fF
C34 a_12956_6092.n4 GND 0.00fF
C35 a_12956_6092.n5 GND 0.01fF
C36 a_12956_6092.n6 GND 0.00fF
C37 a_12956_6092.n7 GND 0.00fF
C38 a_12956_6092.n8 GND 0.00fF
C39 a_12956_6092.n9 GND 0.00fF
C40 a_12956_6092.n10 GND 0.09fF
C41 a_12956_6092.n11 GND 0.00fF
C42 a_12956_6092.n12 GND 0.01fF
C43 a_12956_6092.n13 GND 0.01fF
C44 a_12956_6092.n14 GND 0.01fF
C45 a_12956_6092.n15 GND 0.00fF
C46 a_12956_6092.n16 GND 0.00fF
C47 a_12956_6092.n17 GND 0.00fF
C48 a_12956_6092.t2 GND 0.02fF $ **FLOATING
C49 a_12956_6092.n18 GND 0.07fF
C50 a_12956_6092.n19 GND 0.02fF
C51 a_12956_6092.n20 GND 0.05fF
C52 a_12956_6092.n22 GND 0.04fF
C53 a_12956_6092.n23 GND 0.04fF
C54 a_12956_6092.n24 GND 0.00fF
C55 a_12956_6092.n25 GND 0.00fF
C56 a_12956_6092.t1 GND 0.02fF $ **FLOATING
C57 a_12956_6092.n26 GND 0.07fF
C58 a_12956_6092.n27 GND 0.02fF
C59 a_12956_6092.n28 GND 0.05fF
C60 a_12956_6092.n30 GND 0.01fF
C61 a_12956_6092.n31 GND 0.00fF
C62 a_12956_6092.n32 GND 0.01fF
C63 a_12956_6092.n33 GND 0.00fF
C64 a_12956_6092.n34 GND 0.00fF
C65 a_12956_6092.n35 GND 0.00fF
C66 a_12956_6092.n36 GND 0.00fF
C67 a_12956_6092.n38 GND 0.08fF
C68 a_12956_6092.t3 GND 4.25fF $ **FLOATING
C69 a_12956_6092.n39 GND 0.62fF
C70 a_12956_6092.t0 GND 0.26fF $ **FLOATING
C71 a_5456_4262.n0 GND 0.00fF
C72 a_5456_4262.n1 GND 0.00fF
C73 a_5456_4262.n2 GND 0.01fF
C74 a_5456_4262.n3 GND 0.01fF
C75 a_5456_4262.n4 GND 0.00fF
C76 a_5456_4262.n5 GND 0.01fF
C77 a_5456_4262.n6 GND 0.00fF
C78 a_5456_4262.n7 GND 0.00fF
C79 a_5456_4262.n8 GND 0.00fF
C80 a_5456_4262.n9 GND 0.00fF
C81 a_5456_4262.n10 GND 0.09fF
C82 a_5456_4262.n11 GND 0.00fF
C83 a_5456_4262.n12 GND 0.01fF
C84 a_5456_4262.n13 GND 0.01fF
C85 a_5456_4262.n14 GND 0.01fF
C86 a_5456_4262.n15 GND 0.00fF
C87 a_5456_4262.n16 GND 0.00fF
C88 a_5456_4262.n17 GND 0.00fF
C89 a_5456_4262.t2 GND 0.02fF $ **FLOATING
C90 a_5456_4262.n18 GND 0.07fF
C91 a_5456_4262.n19 GND 0.02fF
C92 a_5456_4262.n20 GND 0.05fF
C93 a_5456_4262.n22 GND 0.04fF
C94 a_5456_4262.n23 GND 0.04fF
C95 a_5456_4262.n24 GND 0.00fF
C96 a_5456_4262.n25 GND 0.00fF
C97 a_5456_4262.t1 GND 0.02fF $ **FLOATING
C98 a_5456_4262.n26 GND 0.07fF
C99 a_5456_4262.n27 GND 0.02fF
C100 a_5456_4262.n28 GND 0.05fF
C101 a_5456_4262.n30 GND 0.01fF
C102 a_5456_4262.n31 GND 0.00fF
C103 a_5456_4262.n32 GND 0.01fF
C104 a_5456_4262.n33 GND 0.00fF
C105 a_5456_4262.n34 GND 0.00fF
C106 a_5456_4262.n35 GND 0.00fF
C107 a_5456_4262.n36 GND 0.00fF
C108 a_5456_4262.n38 GND 0.08fF
C109 a_5456_4262.t3 GND 4.25fF $ **FLOATING
C110 a_5456_4262.n39 GND 0.62fF
C111 a_5456_4262.t0 GND 0.26fF $ **FLOATING
C112 a_1706_9752.n0 GND 0.00fF
C113 a_1706_9752.n1 GND 0.00fF
C114 a_1706_9752.n2 GND 0.01fF
C115 a_1706_9752.n3 GND 0.01fF
C116 a_1706_9752.n4 GND 0.00fF
C117 a_1706_9752.n5 GND 0.01fF
C118 a_1706_9752.n6 GND 0.00fF
C119 a_1706_9752.n7 GND 0.00fF
C120 a_1706_9752.n8 GND 0.00fF
C121 a_1706_9752.n9 GND 0.00fF
C122 a_1706_9752.n10 GND 0.09fF
C123 a_1706_9752.n11 GND 0.00fF
C124 a_1706_9752.n12 GND 0.01fF
C125 a_1706_9752.n13 GND 0.01fF
C126 a_1706_9752.n14 GND 0.01fF
C127 a_1706_9752.n15 GND 0.00fF
C128 a_1706_9752.n16 GND 0.00fF
C129 a_1706_9752.n17 GND 0.00fF
C130 a_1706_9752.t2 GND 0.02fF $ **FLOATING
C131 a_1706_9752.n18 GND 0.07fF
C132 a_1706_9752.n19 GND 0.02fF
C133 a_1706_9752.n20 GND 0.05fF
C134 a_1706_9752.n22 GND 0.04fF
C135 a_1706_9752.n23 GND 0.04fF
C136 a_1706_9752.n24 GND 0.00fF
C137 a_1706_9752.n25 GND 0.00fF
C138 a_1706_9752.t3 GND 0.02fF $ **FLOATING
C139 a_1706_9752.n26 GND 0.07fF
C140 a_1706_9752.n27 GND 0.02fF
C141 a_1706_9752.n28 GND 0.05fF
C142 a_1706_9752.n30 GND 0.01fF
C143 a_1706_9752.n31 GND 0.00fF
C144 a_1706_9752.n32 GND 0.01fF
C145 a_1706_9752.n33 GND 0.00fF
C146 a_1706_9752.n34 GND 0.00fF
C147 a_1706_9752.n35 GND 0.00fF
C148 a_1706_9752.n36 GND 0.00fF
C149 a_1706_9752.n38 GND 0.08fF
C150 a_1706_9752.t1 GND 4.25fF $ **FLOATING
C151 a_1706_9752.n39 GND 0.62fF
C152 a_1706_9752.t0 GND 0.26fF $ **FLOATING
C153 a_27956_7922.n0 GND 0.00fF
C154 a_27956_7922.n1 GND 0.00fF
C155 a_27956_7922.n2 GND 0.01fF
C156 a_27956_7922.n3 GND 0.01fF
C157 a_27956_7922.n4 GND 0.00fF
C158 a_27956_7922.n5 GND 0.01fF
C159 a_27956_7922.n6 GND 0.00fF
C160 a_27956_7922.n7 GND 0.00fF
C161 a_27956_7922.n8 GND 0.00fF
C162 a_27956_7922.n9 GND 0.00fF
C163 a_27956_7922.n10 GND 0.09fF
C164 a_27956_7922.n11 GND 0.00fF
C165 a_27956_7922.n12 GND 0.01fF
C166 a_27956_7922.n13 GND 0.01fF
C167 a_27956_7922.n14 GND 0.01fF
C168 a_27956_7922.n15 GND 0.00fF
C169 a_27956_7922.n16 GND 0.00fF
C170 a_27956_7922.n17 GND 0.00fF
C171 a_27956_7922.t3 GND 0.02fF $ **FLOATING
C172 a_27956_7922.n18 GND 0.07fF
C173 a_27956_7922.n19 GND 0.02fF
C174 a_27956_7922.n20 GND 0.05fF
C175 a_27956_7922.n22 GND 0.04fF
C176 a_27956_7922.n23 GND 0.04fF
C177 a_27956_7922.n24 GND 0.00fF
C178 a_27956_7922.n25 GND 0.00fF
C179 a_27956_7922.t2 GND 0.02fF $ **FLOATING
C180 a_27956_7922.n26 GND 0.07fF
C181 a_27956_7922.n27 GND 0.02fF
C182 a_27956_7922.n28 GND 0.05fF
C183 a_27956_7922.n30 GND 0.01fF
C184 a_27956_7922.n31 GND 0.00fF
C185 a_27956_7922.n32 GND 0.01fF
C186 a_27956_7922.n33 GND 0.00fF
C187 a_27956_7922.n34 GND 0.00fF
C188 a_27956_7922.n35 GND 0.00fF
C189 a_27956_7922.n36 GND 0.00fF
C190 a_27956_7922.n38 GND 0.08fF
C191 a_27956_7922.t1 GND 4.25fF $ **FLOATING
C192 a_27956_7922.n39 GND 0.62fF
C193 a_27956_7922.t0 GND 0.26fF $ **FLOATING
C194 a_20456_6092.n0 GND 0.00fF
C195 a_20456_6092.n1 GND 0.00fF
C196 a_20456_6092.n2 GND 0.01fF
C197 a_20456_6092.n3 GND 0.01fF
C198 a_20456_6092.n4 GND 0.00fF
C199 a_20456_6092.n5 GND 0.01fF
C200 a_20456_6092.n6 GND 0.00fF
C201 a_20456_6092.n7 GND 0.00fF
C202 a_20456_6092.n8 GND 0.00fF
C203 a_20456_6092.n9 GND 0.00fF
C204 a_20456_6092.n10 GND 0.09fF
C205 a_20456_6092.n11 GND 0.00fF
C206 a_20456_6092.n12 GND 0.01fF
C207 a_20456_6092.n13 GND 0.01fF
C208 a_20456_6092.n14 GND 0.01fF
C209 a_20456_6092.n15 GND 0.00fF
C210 a_20456_6092.n16 GND 0.00fF
C211 a_20456_6092.n17 GND 0.00fF
C212 a_20456_6092.t2 GND 0.02fF $ **FLOATING
C213 a_20456_6092.n18 GND 0.07fF
C214 a_20456_6092.n19 GND 0.02fF
C215 a_20456_6092.n20 GND 0.05fF
C216 a_20456_6092.n22 GND 0.04fF
C217 a_20456_6092.n23 GND 0.04fF
C218 a_20456_6092.n24 GND 0.00fF
C219 a_20456_6092.n25 GND 0.00fF
C220 a_20456_6092.t1 GND 0.02fF $ **FLOATING
C221 a_20456_6092.n26 GND 0.07fF
C222 a_20456_6092.n27 GND 0.02fF
C223 a_20456_6092.n28 GND 0.05fF
C224 a_20456_6092.n30 GND 0.01fF
C225 a_20456_6092.n31 GND 0.00fF
C226 a_20456_6092.n32 GND 0.01fF
C227 a_20456_6092.n33 GND 0.00fF
C228 a_20456_6092.n34 GND 0.00fF
C229 a_20456_6092.n35 GND 0.00fF
C230 a_20456_6092.n36 GND 0.00fF
C231 a_20456_6092.n38 GND 0.08fF
C232 a_20456_6092.t3 GND 4.25fF $ **FLOATING
C233 a_20456_6092.n39 GND 0.62fF
C234 a_20456_6092.t0 GND 0.26fF $ **FLOATING
C235 a_27666_4186.n0 GND 0.01fF
C236 a_27666_4186.n1 GND 0.01fF
C237 a_27666_4186.n2 GND 0.00fF
C238 a_27666_4186.n3 GND 0.00fF
C239 a_27666_4186.n4 GND 0.00fF
C240 a_27666_4186.n5 GND 0.00fF
C241 a_27666_4186.n6 GND 0.00fF
C242 a_27666_4186.n7 GND 0.00fF
C243 a_27666_4186.n8 GND 0.00fF
C244 a_27666_4186.n9 GND 0.00fF
C245 a_27666_4186.t2 GND 0.02fF $ **FLOATING
C246 a_27666_4186.t3 GND 0.02fF $ **FLOATING
C247 a_27666_4186.n10 GND 0.05fF
C248 a_27666_4186.n11 GND 0.00fF
C249 a_27666_4186.n12 GND 0.00fF
C250 a_27666_4186.n13 GND 0.02fF
C251 a_27666_4186.n14 GND 0.05fF
C252 a_27666_4186.n15 GND 0.13fF
C253 a_27666_4186.n16 GND 0.01fF
C254 a_27666_4186.n17 GND 0.12fF
C255 a_27666_4186.t1 GND 3.94fF $ **FLOATING
C256 a_27666_4186.n18 GND 0.53fF
C257 a_27666_4186.t0 GND 0.24fF $ **FLOATING
C258 a_12956_2432.n0 GND 0.00fF
C259 a_12956_2432.n1 GND 0.00fF
C260 a_12956_2432.n2 GND 0.01fF
C261 a_12956_2432.n3 GND 0.01fF
C262 a_12956_2432.n4 GND 0.00fF
C263 a_12956_2432.n5 GND 0.01fF
C264 a_12956_2432.n6 GND 0.00fF
C265 a_12956_2432.n7 GND 0.00fF
C266 a_12956_2432.n8 GND 0.00fF
C267 a_12956_2432.n9 GND 0.00fF
C268 a_12956_2432.n10 GND 0.09fF
C269 a_12956_2432.n11 GND 0.00fF
C270 a_12956_2432.n12 GND 0.01fF
C271 a_12956_2432.n13 GND 0.01fF
C272 a_12956_2432.n14 GND 0.01fF
C273 a_12956_2432.n15 GND 0.00fF
C274 a_12956_2432.n16 GND 0.00fF
C275 a_12956_2432.n17 GND 0.00fF
C276 a_12956_2432.t2 GND 0.02fF $ **FLOATING
C277 a_12956_2432.n18 GND 0.07fF
C278 a_12956_2432.n19 GND 0.02fF
C279 a_12956_2432.n20 GND 0.05fF
C280 a_12956_2432.n22 GND 0.04fF
C281 a_12956_2432.n23 GND 0.04fF
C282 a_12956_2432.n24 GND 0.00fF
C283 a_12956_2432.n25 GND 0.00fF
C284 a_12956_2432.t1 GND 0.02fF $ **FLOATING
C285 a_12956_2432.n26 GND 0.07fF
C286 a_12956_2432.n27 GND 0.02fF
C287 a_12956_2432.n28 GND 0.05fF
C288 a_12956_2432.n30 GND 0.01fF
C289 a_12956_2432.n31 GND 0.00fF
C290 a_12956_2432.n32 GND 0.01fF
C291 a_12956_2432.n33 GND 0.00fF
C292 a_12956_2432.n34 GND 0.00fF
C293 a_12956_2432.n35 GND 0.00fF
C294 a_12956_2432.n36 GND 0.00fF
C295 a_12956_2432.n38 GND 0.08fF
C296 a_12956_2432.t3 GND 4.25fF $ **FLOATING
C297 a_12956_2432.n39 GND 0.62fF
C298 a_12956_2432.t0 GND 0.26fF $ **FLOATING
C299 a_20456_2432.n0 GND 0.00fF
C300 a_20456_2432.n1 GND 0.00fF
C301 a_20456_2432.n2 GND 0.01fF
C302 a_20456_2432.n3 GND 0.01fF
C303 a_20456_2432.n4 GND 0.00fF
C304 a_20456_2432.n5 GND 0.01fF
C305 a_20456_2432.n6 GND 0.00fF
C306 a_20456_2432.n7 GND 0.00fF
C307 a_20456_2432.n8 GND 0.00fF
C308 a_20456_2432.n9 GND 0.00fF
C309 a_20456_2432.n10 GND 0.09fF
C310 a_20456_2432.n11 GND 0.00fF
C311 a_20456_2432.n12 GND 0.01fF
C312 a_20456_2432.n13 GND 0.01fF
C313 a_20456_2432.n14 GND 0.01fF
C314 a_20456_2432.n15 GND 0.00fF
C315 a_20456_2432.n16 GND 0.00fF
C316 a_20456_2432.n17 GND 0.00fF
C317 a_20456_2432.t2 GND 0.02fF $ **FLOATING
C318 a_20456_2432.n18 GND 0.07fF
C319 a_20456_2432.n19 GND 0.02fF
C320 a_20456_2432.n20 GND 0.05fF
C321 a_20456_2432.n22 GND 0.04fF
C322 a_20456_2432.n23 GND 0.04fF
C323 a_20456_2432.n24 GND 0.00fF
C324 a_20456_2432.n25 GND 0.00fF
C325 a_20456_2432.t1 GND 0.02fF $ **FLOATING
C326 a_20456_2432.n26 GND 0.07fF
C327 a_20456_2432.n27 GND 0.02fF
C328 a_20456_2432.n28 GND 0.05fF
C329 a_20456_2432.n30 GND 0.01fF
C330 a_20456_2432.n31 GND 0.00fF
C331 a_20456_2432.n32 GND 0.01fF
C332 a_20456_2432.n33 GND 0.00fF
C333 a_20456_2432.n34 GND 0.00fF
C334 a_20456_2432.n35 GND 0.00fF
C335 a_20456_2432.n36 GND 0.00fF
C336 a_20456_2432.n38 GND 0.08fF
C337 a_20456_2432.t3 GND 4.25fF $ **FLOATING
C338 a_20456_2432.n39 GND 0.62fF
C339 a_20456_2432.t0 GND 0.26fF $ **FLOATING
C340 a_9206_7922.n0 GND 0.00fF
C341 a_9206_7922.n1 GND 0.00fF
C342 a_9206_7922.n2 GND 0.01fF
C343 a_9206_7922.n3 GND 0.01fF
C344 a_9206_7922.n4 GND 0.00fF
C345 a_9206_7922.n5 GND 0.01fF
C346 a_9206_7922.n6 GND 0.00fF
C347 a_9206_7922.n7 GND 0.00fF
C348 a_9206_7922.n8 GND 0.00fF
C349 a_9206_7922.n9 GND 0.00fF
C350 a_9206_7922.n10 GND 0.09fF
C351 a_9206_7922.n11 GND 0.00fF
C352 a_9206_7922.n12 GND 0.01fF
C353 a_9206_7922.n13 GND 0.01fF
C354 a_9206_7922.n14 GND 0.01fF
C355 a_9206_7922.n15 GND 0.00fF
C356 a_9206_7922.n16 GND 0.00fF
C357 a_9206_7922.n17 GND 0.00fF
C358 a_9206_7922.t2 GND 0.02fF $ **FLOATING
C359 a_9206_7922.n18 GND 0.07fF
C360 a_9206_7922.n19 GND 0.02fF
C361 a_9206_7922.n20 GND 0.05fF
C362 a_9206_7922.n22 GND 0.04fF
C363 a_9206_7922.n23 GND 0.04fF
C364 a_9206_7922.n24 GND 0.00fF
C365 a_9206_7922.n25 GND 0.00fF
C366 a_9206_7922.t3 GND 0.02fF $ **FLOATING
C367 a_9206_7922.n26 GND 0.07fF
C368 a_9206_7922.n27 GND 0.02fF
C369 a_9206_7922.n28 GND 0.05fF
C370 a_9206_7922.n30 GND 0.01fF
C371 a_9206_7922.n31 GND 0.00fF
C372 a_9206_7922.n32 GND 0.01fF
C373 a_9206_7922.n33 GND 0.00fF
C374 a_9206_7922.n34 GND 0.00fF
C375 a_9206_7922.n35 GND 0.00fF
C376 a_9206_7922.n36 GND 0.00fF
C377 a_9206_7922.n38 GND 0.08fF
C378 a_9206_7922.t1 GND 4.25fF $ **FLOATING
C379 a_9206_7922.n39 GND 0.62fF
C380 a_9206_7922.t0 GND 0.26fF $ **FLOATING
C381 a_24206_6092.n0 GND 0.00fF
C382 a_24206_6092.n1 GND 0.00fF
C383 a_24206_6092.n2 GND 0.01fF
C384 a_24206_6092.n3 GND 0.01fF
C385 a_24206_6092.n4 GND 0.00fF
C386 a_24206_6092.n5 GND 0.01fF
C387 a_24206_6092.n6 GND 0.00fF
C388 a_24206_6092.n7 GND 0.00fF
C389 a_24206_6092.n8 GND 0.00fF
C390 a_24206_6092.n9 GND 0.00fF
C391 a_24206_6092.n10 GND 0.09fF
C392 a_24206_6092.n11 GND 0.00fF
C393 a_24206_6092.n12 GND 0.01fF
C394 a_24206_6092.n13 GND 0.01fF
C395 a_24206_6092.n14 GND 0.01fF
C396 a_24206_6092.n15 GND 0.00fF
C397 a_24206_6092.n16 GND 0.00fF
C398 a_24206_6092.n17 GND 0.00fF
C399 a_24206_6092.t1 GND 0.02fF $ **FLOATING
C400 a_24206_6092.n18 GND 0.07fF
C401 a_24206_6092.n19 GND 0.02fF
C402 a_24206_6092.n20 GND 0.05fF
C403 a_24206_6092.n22 GND 0.04fF
C404 a_24206_6092.n23 GND 0.04fF
C405 a_24206_6092.n24 GND 0.00fF
C406 a_24206_6092.n25 GND 0.00fF
C407 a_24206_6092.t2 GND 0.02fF $ **FLOATING
C408 a_24206_6092.n26 GND 0.07fF
C409 a_24206_6092.n27 GND 0.02fF
C410 a_24206_6092.n28 GND 0.05fF
C411 a_24206_6092.n30 GND 0.01fF
C412 a_24206_6092.n31 GND 0.00fF
C413 a_24206_6092.n32 GND 0.01fF
C414 a_24206_6092.n33 GND 0.00fF
C415 a_24206_6092.n34 GND 0.00fF
C416 a_24206_6092.n35 GND 0.00fF
C417 a_24206_6092.n36 GND 0.00fF
C418 a_24206_6092.n38 GND 0.08fF
C419 a_24206_6092.t3 GND 4.25fF $ **FLOATING
C420 a_24206_6092.n39 GND 0.62fF
C421 a_24206_6092.t0 GND 0.26fF $ **FLOATING
C422 a_27956_602.n0 GND 0.00fF
C423 a_27956_602.n1 GND 0.00fF
C424 a_27956_602.n2 GND 0.01fF
C425 a_27956_602.n3 GND 0.01fF
C426 a_27956_602.n4 GND 0.00fF
C427 a_27956_602.n5 GND 0.01fF
C428 a_27956_602.n6 GND 0.00fF
C429 a_27956_602.n7 GND 0.00fF
C430 a_27956_602.n8 GND 0.00fF
C431 a_27956_602.n9 GND 0.00fF
C432 a_27956_602.n10 GND 0.09fF
C433 a_27956_602.n11 GND 0.00fF
C434 a_27956_602.n12 GND 0.01fF
C435 a_27956_602.n13 GND 0.01fF
C436 a_27956_602.n14 GND 0.01fF
C437 a_27956_602.n15 GND 0.00fF
C438 a_27956_602.n16 GND 0.00fF
C439 a_27956_602.n17 GND 0.00fF
C440 a_27956_602.t2 GND 0.02fF $ **FLOATING
C441 a_27956_602.n18 GND 0.07fF
C442 a_27956_602.n19 GND 0.02fF
C443 a_27956_602.n20 GND 0.05fF
C444 a_27956_602.n22 GND 0.04fF
C445 a_27956_602.n23 GND 0.04fF
C446 a_27956_602.n24 GND 0.00fF
C447 a_27956_602.n25 GND 0.00fF
C448 a_27956_602.t1 GND 0.02fF $ **FLOATING
C449 a_27956_602.n26 GND 0.07fF
C450 a_27956_602.n27 GND 0.02fF
C451 a_27956_602.n28 GND 0.05fF
C452 a_27956_602.n30 GND 0.01fF
C453 a_27956_602.n31 GND 0.00fF
C454 a_27956_602.n32 GND 0.01fF
C455 a_27956_602.n33 GND 0.00fF
C456 a_27956_602.n34 GND 0.00fF
C457 a_27956_602.n35 GND 0.00fF
C458 a_27956_602.n36 GND 0.00fF
C459 a_27956_602.n38 GND 0.08fF
C460 a_27956_602.t3 GND 4.25fF $ **FLOATING
C461 a_27956_602.n39 GND 0.62fF
C462 a_27956_602.t0 GND 0.26fF $ **FLOATING
C463 a_5166_4186.n0 GND 0.01fF
C464 a_5166_4186.n1 GND 0.01fF
C465 a_5166_4186.n2 GND 0.00fF
C466 a_5166_4186.n3 GND 0.00fF
C467 a_5166_4186.n4 GND 0.00fF
C468 a_5166_4186.n5 GND 0.00fF
C469 a_5166_4186.n6 GND 0.00fF
C470 a_5166_4186.n7 GND 0.00fF
C471 a_5166_4186.n8 GND 0.00fF
C472 a_5166_4186.n9 GND 0.00fF
C473 a_5166_4186.t2 GND 0.02fF $ **FLOATING
C474 a_5166_4186.t3 GND 0.02fF $ **FLOATING
C475 a_5166_4186.n10 GND 0.05fF
C476 a_5166_4186.n11 GND 0.00fF
C477 a_5166_4186.n12 GND 0.00fF
C478 a_5166_4186.n13 GND 0.02fF
C479 a_5166_4186.n14 GND 0.05fF
C480 a_5166_4186.n15 GND 0.13fF
C481 a_5166_4186.n16 GND 0.01fF
C482 a_5166_4186.n17 GND 0.12fF
C483 a_5166_4186.t1 GND 3.94fF $ **FLOATING
C484 a_5166_4186.n18 GND 0.53fF
C485 a_5166_4186.t0 GND 0.24fF $ **FLOATING
C486 a_23916_9676.n0 GND 0.01fF
C487 a_23916_9676.n1 GND 0.01fF
C488 a_23916_9676.n2 GND 0.00fF
C489 a_23916_9676.n3 GND 0.00fF
C490 a_23916_9676.n4 GND 0.00fF
C491 a_23916_9676.n5 GND 0.00fF
C492 a_23916_9676.n6 GND 0.00fF
C493 a_23916_9676.n7 GND 0.00fF
C494 a_23916_9676.n8 GND 0.00fF
C495 a_23916_9676.n9 GND 0.00fF
C496 a_23916_9676.t3 GND 0.02fF $ **FLOATING
C497 a_23916_9676.t2 GND 0.02fF $ **FLOATING
C498 a_23916_9676.n10 GND 0.05fF
C499 a_23916_9676.n11 GND 0.00fF
C500 a_23916_9676.n12 GND 0.00fF
C501 a_23916_9676.n13 GND 0.02fF
C502 a_23916_9676.n14 GND 0.05fF
C503 a_23916_9676.n15 GND 0.13fF
C504 a_23916_9676.n16 GND 0.01fF
C505 a_23916_9676.n17 GND 0.12fF
C506 a_23916_9676.t1 GND 3.94fF $ **FLOATING
C507 a_23916_9676.n18 GND 0.53fF
C508 a_23916_9676.t0 GND 0.24fF $ **FLOATING
C509 a_12666_9676.n0 GND 0.01fF
C510 a_12666_9676.n1 GND 0.01fF
C511 a_12666_9676.n2 GND 0.00fF
C512 a_12666_9676.n3 GND 0.00fF
C513 a_12666_9676.n4 GND 0.00fF
C514 a_12666_9676.n5 GND 0.00fF
C515 a_12666_9676.n6 GND 0.00fF
C516 a_12666_9676.n7 GND 0.00fF
C517 a_12666_9676.n8 GND 0.00fF
C518 a_12666_9676.n9 GND 0.00fF
C519 a_12666_9676.t2 GND 0.02fF $ **FLOATING
C520 a_12666_9676.t3 GND 0.02fF $ **FLOATING
C521 a_12666_9676.n10 GND 0.05fF
C522 a_12666_9676.n11 GND 0.00fF
C523 a_12666_9676.n12 GND 0.00fF
C524 a_12666_9676.n13 GND 0.02fF
C525 a_12666_9676.n14 GND 0.05fF
C526 a_12666_9676.n15 GND 0.13fF
C527 a_12666_9676.n16 GND 0.01fF
C528 a_12666_9676.n17 GND 0.12fF
C529 a_12666_9676.t0 GND 3.94fF $ **FLOATING
C530 a_12666_9676.n18 GND 0.53fF
C531 a_12666_9676.t1 GND 0.24fF $ **FLOATING
C532 a_5166_9676.n0 GND 0.01fF
C533 a_5166_9676.n1 GND 0.01fF
C534 a_5166_9676.n2 GND 0.00fF
C535 a_5166_9676.n3 GND 0.00fF
C536 a_5166_9676.n4 GND 0.00fF
C537 a_5166_9676.n5 GND 0.00fF
C538 a_5166_9676.n6 GND 0.00fF
C539 a_5166_9676.n7 GND 0.00fF
C540 a_5166_9676.n8 GND 0.00fF
C541 a_5166_9676.n9 GND 0.00fF
C542 a_5166_9676.t2 GND 0.02fF $ **FLOATING
C543 a_5166_9676.t3 GND 0.02fF $ **FLOATING
C544 a_5166_9676.n10 GND 0.05fF
C545 a_5166_9676.n11 GND 0.00fF
C546 a_5166_9676.n12 GND 0.00fF
C547 a_5166_9676.n13 GND 0.02fF
C548 a_5166_9676.n14 GND 0.05fF
C549 a_5166_9676.n15 GND 0.13fF
C550 a_5166_9676.n16 GND 0.01fF
C551 a_5166_9676.n17 GND 0.12fF
C552 a_5166_9676.t1 GND 3.94fF $ **FLOATING
C553 a_5166_9676.n18 GND 0.53fF
C554 a_5166_9676.t0 GND 0.24fF $ **FLOATING
C555 a_5166_526.n0 GND 0.01fF
C556 a_5166_526.n1 GND 0.01fF
C557 a_5166_526.n2 GND 0.00fF
C558 a_5166_526.n3 GND 0.00fF
C559 a_5166_526.n4 GND 0.00fF
C560 a_5166_526.n5 GND 0.00fF
C561 a_5166_526.n6 GND 0.00fF
C562 a_5166_526.n7 GND 0.00fF
C563 a_5166_526.n8 GND 0.00fF
C564 a_5166_526.n9 GND 0.00fF
C565 a_5166_526.t2 GND 0.02fF $ **FLOATING
C566 a_5166_526.t3 GND 0.02fF $ **FLOATING
C567 a_5166_526.n10 GND 0.05fF
C568 a_5166_526.n11 GND 0.00fF
C569 a_5166_526.n12 GND 0.00fF
C570 a_5166_526.n13 GND 0.02fF
C571 a_5166_526.n14 GND 0.05fF
C572 a_5166_526.n15 GND 0.13fF
C573 a_5166_526.n16 GND 0.01fF
C574 a_5166_526.n17 GND 0.12fF
C575 a_5166_526.t1 GND 3.94fF $ **FLOATING
C576 a_5166_526.n18 GND 0.53fF
C577 a_5166_526.t0 GND 0.24fF $ **FLOATING
C578 a_27956_4262.n0 GND 0.00fF
C579 a_27956_4262.n1 GND 0.00fF
C580 a_27956_4262.n2 GND 0.01fF
C581 a_27956_4262.n3 GND 0.01fF
C582 a_27956_4262.n4 GND 0.00fF
C583 a_27956_4262.n5 GND 0.01fF
C584 a_27956_4262.n6 GND 0.00fF
C585 a_27956_4262.n7 GND 0.00fF
C586 a_27956_4262.n8 GND 0.00fF
C587 a_27956_4262.n9 GND 0.00fF
C588 a_27956_4262.n10 GND 0.09fF
C589 a_27956_4262.n11 GND 0.00fF
C590 a_27956_4262.n12 GND 0.01fF
C591 a_27956_4262.n13 GND 0.01fF
C592 a_27956_4262.n14 GND 0.01fF
C593 a_27956_4262.n15 GND 0.00fF
C594 a_27956_4262.n16 GND 0.00fF
C595 a_27956_4262.n17 GND 0.00fF
C596 a_27956_4262.t2 GND 0.02fF $ **FLOATING
C597 a_27956_4262.n18 GND 0.07fF
C598 a_27956_4262.n19 GND 0.02fF
C599 a_27956_4262.n20 GND 0.05fF
C600 a_27956_4262.n22 GND 0.04fF
C601 a_27956_4262.n23 GND 0.04fF
C602 a_27956_4262.n24 GND 0.00fF
C603 a_27956_4262.n25 GND 0.00fF
C604 a_27956_4262.t1 GND 0.02fF $ **FLOATING
C605 a_27956_4262.n26 GND 0.07fF
C606 a_27956_4262.n27 GND 0.02fF
C607 a_27956_4262.n28 GND 0.05fF
C608 a_27956_4262.n30 GND 0.01fF
C609 a_27956_4262.n31 GND 0.00fF
C610 a_27956_4262.n32 GND 0.01fF
C611 a_27956_4262.n33 GND 0.00fF
C612 a_27956_4262.n34 GND 0.00fF
C613 a_27956_4262.n35 GND 0.00fF
C614 a_27956_4262.n36 GND 0.00fF
C615 a_27956_4262.n38 GND 0.08fF
C616 a_27956_4262.t3 GND 4.25fF $ **FLOATING
C617 a_27956_4262.n39 GND 0.62fF
C618 a_27956_4262.t0 GND 0.26fF $ **FLOATING
C619 a_5166_7846.n0 GND 0.01fF
C620 a_5166_7846.n1 GND 0.01fF
C621 a_5166_7846.n2 GND 0.00fF
C622 a_5166_7846.n3 GND 0.00fF
C623 a_5166_7846.n4 GND 0.00fF
C624 a_5166_7846.n5 GND 0.00fF
C625 a_5166_7846.n6 GND 0.00fF
C626 a_5166_7846.n7 GND 0.00fF
C627 a_5166_7846.n8 GND 0.00fF
C628 a_5166_7846.n9 GND 0.00fF
C629 a_5166_7846.t2 GND 0.02fF $ **FLOATING
C630 a_5166_7846.t3 GND 0.02fF $ **FLOATING
C631 a_5166_7846.n10 GND 0.05fF
C632 a_5166_7846.n11 GND 0.00fF
C633 a_5166_7846.n12 GND 0.00fF
C634 a_5166_7846.n13 GND 0.02fF
C635 a_5166_7846.n14 GND 0.05fF
C636 a_5166_7846.n15 GND 0.13fF
C637 a_5166_7846.n16 GND 0.01fF
C638 a_5166_7846.n17 GND 0.12fF
C639 a_5166_7846.t1 GND 3.94fF $ **FLOATING
C640 a_5166_7846.n18 GND 0.53fF
C641 a_5166_7846.t0 GND 0.24fF $ **FLOATING
C642 a_24206_9752.n0 GND 0.00fF
C643 a_24206_9752.n1 GND 0.00fF
C644 a_24206_9752.n2 GND 0.01fF
C645 a_24206_9752.n3 GND 0.01fF
C646 a_24206_9752.n4 GND 0.00fF
C647 a_24206_9752.n5 GND 0.01fF
C648 a_24206_9752.n6 GND 0.00fF
C649 a_24206_9752.n7 GND 0.00fF
C650 a_24206_9752.n8 GND 0.00fF
C651 a_24206_9752.n9 GND 0.00fF
C652 a_24206_9752.n10 GND 0.09fF
C653 a_24206_9752.n11 GND 0.00fF
C654 a_24206_9752.n12 GND 0.01fF
C655 a_24206_9752.n13 GND 0.01fF
C656 a_24206_9752.n14 GND 0.01fF
C657 a_24206_9752.n15 GND 0.00fF
C658 a_24206_9752.n16 GND 0.00fF
C659 a_24206_9752.n17 GND 0.00fF
C660 a_24206_9752.t2 GND 0.02fF $ **FLOATING
C661 a_24206_9752.n18 GND 0.07fF
C662 a_24206_9752.n19 GND 0.02fF
C663 a_24206_9752.n20 GND 0.05fF
C664 a_24206_9752.n22 GND 0.04fF
C665 a_24206_9752.n23 GND 0.04fF
C666 a_24206_9752.n24 GND 0.00fF
C667 a_24206_9752.n25 GND 0.00fF
C668 a_24206_9752.t3 GND 0.02fF $ **FLOATING
C669 a_24206_9752.n26 GND 0.07fF
C670 a_24206_9752.n27 GND 0.02fF
C671 a_24206_9752.n28 GND 0.05fF
C672 a_24206_9752.n30 GND 0.01fF
C673 a_24206_9752.n31 GND 0.00fF
C674 a_24206_9752.n32 GND 0.01fF
C675 a_24206_9752.n33 GND 0.00fF
C676 a_24206_9752.n34 GND 0.00fF
C677 a_24206_9752.n35 GND 0.00fF
C678 a_24206_9752.n36 GND 0.00fF
C679 a_24206_9752.n38 GND 0.08fF
C680 a_24206_9752.t1 GND 4.25fF $ **FLOATING
C681 a_24206_9752.n39 GND 0.62fF
C682 a_24206_9752.t0 GND 0.26fF $ **FLOATING
C683 a_16416_11506.n0 GND 0.01fF
C684 a_16416_11506.n1 GND 0.01fF
C685 a_16416_11506.n2 GND 0.00fF
C686 a_16416_11506.n3 GND 0.00fF
C687 a_16416_11506.n4 GND 0.00fF
C688 a_16416_11506.n5 GND 0.00fF
C689 a_16416_11506.n6 GND 0.00fF
C690 a_16416_11506.n7 GND 0.00fF
C691 a_16416_11506.n8 GND 0.00fF
C692 a_16416_11506.n9 GND 0.00fF
C693 a_16416_11506.t2 GND 0.02fF $ **FLOATING
C694 a_16416_11506.t1 GND 0.02fF $ **FLOATING
C695 a_16416_11506.n10 GND 0.05fF
C696 a_16416_11506.n11 GND 0.00fF
C697 a_16416_11506.n12 GND 0.00fF
C698 a_16416_11506.n13 GND 0.02fF
C699 a_16416_11506.n14 GND 0.05fF
C700 a_16416_11506.n15 GND 0.13fF
C701 a_16416_11506.n16 GND 0.01fF
C702 a_16416_11506.n17 GND 0.12fF
C703 a_16416_11506.t0 GND 3.94fF $ **FLOATING
C704 a_16416_11506.n18 GND 0.53fF
C705 a_16416_11506.t3 GND 0.24fF $ **FLOATING
C706 a_5166_15166.n0 GND 0.01fF
C707 a_5166_15166.n1 GND 0.01fF
C708 a_5166_15166.n2 GND 0.00fF
C709 a_5166_15166.n3 GND 0.00fF
C710 a_5166_15166.n4 GND 0.00fF
C711 a_5166_15166.n5 GND 0.00fF
C712 a_5166_15166.n6 GND 0.00fF
C713 a_5166_15166.n7 GND 0.00fF
C714 a_5166_15166.n8 GND 0.00fF
C715 a_5166_15166.n9 GND 0.00fF
C716 a_5166_15166.t2 GND 0.02fF $ **FLOATING
C717 a_5166_15166.t3 GND 0.02fF $ **FLOATING
C718 a_5166_15166.n10 GND 0.05fF
C719 a_5166_15166.n11 GND 0.00fF
C720 a_5166_15166.n12 GND 0.00fF
C721 a_5166_15166.n13 GND 0.02fF
C722 a_5166_15166.n14 GND 0.05fF
C723 a_5166_15166.n15 GND 0.13fF
C724 a_5166_15166.n16 GND 0.01fF
C725 a_5166_15166.n17 GND 0.12fF
C726 a_5166_15166.t1 GND 3.94fF $ **FLOATING
C727 a_5166_15166.n18 GND 0.53fF
C728 a_5166_15166.t0 GND 0.24fF $ **FLOATING
C729 a_12956_9752.n0 GND 0.00fF
C730 a_12956_9752.n1 GND 0.00fF
C731 a_12956_9752.n2 GND 0.01fF
C732 a_12956_9752.n3 GND 0.01fF
C733 a_12956_9752.n4 GND 0.00fF
C734 a_12956_9752.n5 GND 0.01fF
C735 a_12956_9752.n6 GND 0.00fF
C736 a_12956_9752.n7 GND 0.00fF
C737 a_12956_9752.n8 GND 0.00fF
C738 a_12956_9752.n9 GND 0.00fF
C739 a_12956_9752.n10 GND 0.09fF
C740 a_12956_9752.n11 GND 0.00fF
C741 a_12956_9752.n12 GND 0.01fF
C742 a_12956_9752.n13 GND 0.01fF
C743 a_12956_9752.n14 GND 0.01fF
C744 a_12956_9752.n15 GND 0.00fF
C745 a_12956_9752.n16 GND 0.00fF
C746 a_12956_9752.n17 GND 0.00fF
C747 a_12956_9752.t3 GND 0.02fF $ **FLOATING
C748 a_12956_9752.n18 GND 0.07fF
C749 a_12956_9752.n19 GND 0.02fF
C750 a_12956_9752.n20 GND 0.05fF
C751 a_12956_9752.n22 GND 0.04fF
C752 a_12956_9752.n23 GND 0.04fF
C753 a_12956_9752.n24 GND 0.00fF
C754 a_12956_9752.n25 GND 0.00fF
C755 a_12956_9752.t2 GND 0.02fF $ **FLOATING
C756 a_12956_9752.n26 GND 0.07fF
C757 a_12956_9752.n27 GND 0.02fF
C758 a_12956_9752.n28 GND 0.05fF
C759 a_12956_9752.n30 GND 0.01fF
C760 a_12956_9752.n31 GND 0.00fF
C761 a_12956_9752.n32 GND 0.01fF
C762 a_12956_9752.n33 GND 0.00fF
C763 a_12956_9752.n34 GND 0.00fF
C764 a_12956_9752.n35 GND 0.00fF
C765 a_12956_9752.n36 GND 0.00fF
C766 a_12956_9752.n38 GND 0.08fF
C767 a_12956_9752.t1 GND 4.25fF $ **FLOATING
C768 a_12956_9752.n39 GND 0.62fF
C769 a_12956_9752.t0 GND 0.26fF $ **FLOATING
C770 a_5456_11582.n0 GND 0.00fF
C771 a_5456_11582.n1 GND 0.00fF
C772 a_5456_11582.n2 GND 0.01fF
C773 a_5456_11582.n3 GND 0.01fF
C774 a_5456_11582.n4 GND 0.00fF
C775 a_5456_11582.n5 GND 0.01fF
C776 a_5456_11582.n6 GND 0.00fF
C777 a_5456_11582.n7 GND 0.00fF
C778 a_5456_11582.n8 GND 0.00fF
C779 a_5456_11582.n9 GND 0.00fF
C780 a_5456_11582.n10 GND 0.09fF
C781 a_5456_11582.n11 GND 0.00fF
C782 a_5456_11582.n12 GND 0.01fF
C783 a_5456_11582.n13 GND 0.01fF
C784 a_5456_11582.n14 GND 0.01fF
C785 a_5456_11582.n15 GND 0.00fF
C786 a_5456_11582.n16 GND 0.00fF
C787 a_5456_11582.n17 GND 0.00fF
C788 a_5456_11582.t2 GND 0.02fF $ **FLOATING
C789 a_5456_11582.n18 GND 0.07fF
C790 a_5456_11582.n19 GND 0.02fF
C791 a_5456_11582.n20 GND 0.05fF
C792 a_5456_11582.n22 GND 0.04fF
C793 a_5456_11582.n23 GND 0.04fF
C794 a_5456_11582.n24 GND 0.00fF
C795 a_5456_11582.n25 GND 0.00fF
C796 a_5456_11582.t1 GND 0.02fF $ **FLOATING
C797 a_5456_11582.n26 GND 0.07fF
C798 a_5456_11582.n27 GND 0.02fF
C799 a_5456_11582.n28 GND 0.05fF
C800 a_5456_11582.n30 GND 0.01fF
C801 a_5456_11582.n31 GND 0.00fF
C802 a_5456_11582.n32 GND 0.01fF
C803 a_5456_11582.n33 GND 0.00fF
C804 a_5456_11582.n34 GND 0.00fF
C805 a_5456_11582.n35 GND 0.00fF
C806 a_5456_11582.n36 GND 0.00fF
C807 a_5456_11582.n38 GND 0.08fF
C808 a_5456_11582.t3 GND 4.25fF $ **FLOATING
C809 a_5456_11582.n39 GND 0.62fF
C810 a_5456_11582.t0 GND 0.26fF $ **FLOATING
C811 a_5166_11506.n0 GND 0.01fF
C812 a_5166_11506.n1 GND 0.01fF
C813 a_5166_11506.n2 GND 0.00fF
C814 a_5166_11506.n3 GND 0.00fF
C815 a_5166_11506.n4 GND 0.00fF
C816 a_5166_11506.n5 GND 0.00fF
C817 a_5166_11506.n6 GND 0.00fF
C818 a_5166_11506.n7 GND 0.00fF
C819 a_5166_11506.n8 GND 0.00fF
C820 a_5166_11506.n9 GND 0.00fF
C821 a_5166_11506.t1 GND 0.02fF $ **FLOATING
C822 a_5166_11506.t2 GND 0.02fF $ **FLOATING
C823 a_5166_11506.n10 GND 0.05fF
C824 a_5166_11506.n11 GND 0.00fF
C825 a_5166_11506.n12 GND 0.00fF
C826 a_5166_11506.n13 GND 0.02fF
C827 a_5166_11506.n14 GND 0.05fF
C828 a_5166_11506.n15 GND 0.13fF
C829 a_5166_11506.n16 GND 0.01fF
C830 a_5166_11506.n17 GND 0.12fF
C831 a_5166_11506.t0 GND 3.94fF $ **FLOATING
C832 a_5166_11506.n18 GND 0.53fF
C833 a_5166_11506.t3 GND 0.24fF $ **FLOATING
C834 a_9206_11582.n0 GND 0.00fF
C835 a_9206_11582.n1 GND 0.00fF
C836 a_9206_11582.n2 GND 0.01fF
C837 a_9206_11582.n3 GND 0.01fF
C838 a_9206_11582.n4 GND 0.00fF
C839 a_9206_11582.n5 GND 0.01fF
C840 a_9206_11582.n6 GND 0.00fF
C841 a_9206_11582.n7 GND 0.00fF
C842 a_9206_11582.n8 GND 0.00fF
C843 a_9206_11582.n9 GND 0.00fF
C844 a_9206_11582.n10 GND 0.09fF
C845 a_9206_11582.n11 GND 0.00fF
C846 a_9206_11582.n12 GND 0.01fF
C847 a_9206_11582.n13 GND 0.01fF
C848 a_9206_11582.n14 GND 0.01fF
C849 a_9206_11582.n15 GND 0.00fF
C850 a_9206_11582.n16 GND 0.00fF
C851 a_9206_11582.n17 GND 0.00fF
C852 a_9206_11582.t2 GND 0.02fF $ **FLOATING
C853 a_9206_11582.n18 GND 0.07fF
C854 a_9206_11582.n19 GND 0.02fF
C855 a_9206_11582.n20 GND 0.05fF
C856 a_9206_11582.n22 GND 0.04fF
C857 a_9206_11582.n23 GND 0.04fF
C858 a_9206_11582.n24 GND 0.00fF
C859 a_9206_11582.n25 GND 0.00fF
C860 a_9206_11582.t1 GND 0.02fF $ **FLOATING
C861 a_9206_11582.n26 GND 0.07fF
C862 a_9206_11582.n27 GND 0.02fF
C863 a_9206_11582.n28 GND 0.05fF
C864 a_9206_11582.n30 GND 0.01fF
C865 a_9206_11582.n31 GND 0.00fF
C866 a_9206_11582.n32 GND 0.01fF
C867 a_9206_11582.n33 GND 0.00fF
C868 a_9206_11582.n34 GND 0.00fF
C869 a_9206_11582.n35 GND 0.00fF
C870 a_9206_11582.n36 GND 0.00fF
C871 a_9206_11582.n38 GND 0.08fF
C872 a_9206_11582.t3 GND 4.25fF $ **FLOATING
C873 a_9206_11582.n39 GND 0.62fF
C874 a_9206_11582.t0 GND 0.26fF $ **FLOATING
C875 a_8916_4186.n0 GND 0.01fF
C876 a_8916_4186.n1 GND 0.01fF
C877 a_8916_4186.n2 GND 0.00fF
C878 a_8916_4186.n3 GND 0.00fF
C879 a_8916_4186.n4 GND 0.00fF
C880 a_8916_4186.n5 GND 0.00fF
C881 a_8916_4186.n6 GND 0.00fF
C882 a_8916_4186.n7 GND 0.00fF
C883 a_8916_4186.n8 GND 0.00fF
C884 a_8916_4186.n9 GND 0.00fF
C885 a_8916_4186.t3 GND 0.02fF $ **FLOATING
C886 a_8916_4186.t2 GND 0.02fF $ **FLOATING
C887 a_8916_4186.n10 GND 0.05fF
C888 a_8916_4186.n11 GND 0.00fF
C889 a_8916_4186.n12 GND 0.00fF
C890 a_8916_4186.n13 GND 0.02fF
C891 a_8916_4186.n14 GND 0.05fF
C892 a_8916_4186.n15 GND 0.13fF
C893 a_8916_4186.n16 GND 0.01fF
C894 a_8916_4186.n17 GND 0.12fF
C895 a_8916_4186.t1 GND 3.94fF $ **FLOATING
C896 a_8916_4186.n18 GND 0.53fF
C897 a_8916_4186.t0 GND 0.24fF $ **FLOATING
C898 a_27956_6092.n0 GND 0.00fF
C899 a_27956_6092.n1 GND 0.00fF
C900 a_27956_6092.n2 GND 0.01fF
C901 a_27956_6092.n3 GND 0.01fF
C902 a_27956_6092.n4 GND 0.00fF
C903 a_27956_6092.n5 GND 0.01fF
C904 a_27956_6092.n6 GND 0.00fF
C905 a_27956_6092.n7 GND 0.00fF
C906 a_27956_6092.n8 GND 0.00fF
C907 a_27956_6092.n9 GND 0.00fF
C908 a_27956_6092.n10 GND 0.09fF
C909 a_27956_6092.n11 GND 0.00fF
C910 a_27956_6092.n12 GND 0.01fF
C911 a_27956_6092.n13 GND 0.01fF
C912 a_27956_6092.n14 GND 0.01fF
C913 a_27956_6092.n15 GND 0.00fF
C914 a_27956_6092.n16 GND 0.00fF
C915 a_27956_6092.n17 GND 0.00fF
C916 a_27956_6092.t2 GND 0.02fF $ **FLOATING
C917 a_27956_6092.n18 GND 0.07fF
C918 a_27956_6092.n19 GND 0.02fF
C919 a_27956_6092.n20 GND 0.05fF
C920 a_27956_6092.n22 GND 0.04fF
C921 a_27956_6092.n23 GND 0.04fF
C922 a_27956_6092.n24 GND 0.00fF
C923 a_27956_6092.n25 GND 0.00fF
C924 a_27956_6092.t1 GND 0.02fF $ **FLOATING
C925 a_27956_6092.n26 GND 0.07fF
C926 a_27956_6092.n27 GND 0.02fF
C927 a_27956_6092.n28 GND 0.05fF
C928 a_27956_6092.n30 GND 0.01fF
C929 a_27956_6092.n31 GND 0.00fF
C930 a_27956_6092.n32 GND 0.01fF
C931 a_27956_6092.n33 GND 0.00fF
C932 a_27956_6092.n34 GND 0.00fF
C933 a_27956_6092.n35 GND 0.00fF
C934 a_27956_6092.n36 GND 0.00fF
C935 a_27956_6092.n38 GND 0.08fF
C936 a_27956_6092.t3 GND 4.25fF $ **FLOATING
C937 a_27956_6092.n39 GND 0.62fF
C938 a_27956_6092.t0 GND 0.26fF $ **FLOATING
C939 a_8916_13336.n0 GND 0.01fF
C940 a_8916_13336.n1 GND 0.01fF
C941 a_8916_13336.n2 GND 0.00fF
C942 a_8916_13336.n3 GND 0.00fF
C943 a_8916_13336.n4 GND 0.00fF
C944 a_8916_13336.n5 GND 0.00fF
C945 a_8916_13336.n6 GND 0.00fF
C946 a_8916_13336.n7 GND 0.00fF
C947 a_8916_13336.n8 GND 0.00fF
C948 a_8916_13336.n9 GND 0.00fF
C949 a_8916_13336.t3 GND 0.02fF $ **FLOATING
C950 a_8916_13336.t2 GND 0.02fF $ **FLOATING
C951 a_8916_13336.n10 GND 0.05fF
C952 a_8916_13336.n11 GND 0.00fF
C953 a_8916_13336.n12 GND 0.00fF
C954 a_8916_13336.n13 GND 0.02fF
C955 a_8916_13336.n14 GND 0.05fF
C956 a_8916_13336.n15 GND 0.13fF
C957 a_8916_13336.n16 GND 0.01fF
C958 a_8916_13336.n17 GND 0.12fF
C959 a_8916_13336.t1 GND 3.94fF $ **FLOATING
C960 a_8916_13336.n18 GND 0.53fF
C961 a_8916_13336.t0 GND 0.24fF $ **FLOATING
C962 a_20166_6016.n0 GND 0.01fF
C963 a_20166_6016.n1 GND 0.01fF
C964 a_20166_6016.n2 GND 0.00fF
C965 a_20166_6016.n3 GND 0.00fF
C966 a_20166_6016.n4 GND 0.00fF
C967 a_20166_6016.n5 GND 0.00fF
C968 a_20166_6016.n6 GND 0.00fF
C969 a_20166_6016.n7 GND 0.00fF
C970 a_20166_6016.n8 GND 0.00fF
C971 a_20166_6016.n9 GND 0.00fF
C972 a_20166_6016.t2 GND 0.02fF $ **FLOATING
C973 a_20166_6016.t3 GND 0.02fF $ **FLOATING
C974 a_20166_6016.n10 GND 0.05fF
C975 a_20166_6016.n11 GND 0.00fF
C976 a_20166_6016.n12 GND 0.00fF
C977 a_20166_6016.n13 GND 0.02fF
C978 a_20166_6016.n14 GND 0.05fF
C979 a_20166_6016.n15 GND 0.13fF
C980 a_20166_6016.n16 GND 0.01fF
C981 a_20166_6016.n17 GND 0.12fF
C982 a_20166_6016.t0 GND 3.94fF $ **FLOATING
C983 a_20166_6016.n18 GND 0.53fF
C984 a_20166_6016.t1 GND 0.24fF $ **FLOATING
C985 a_16416_7846.n0 GND 0.01fF
C986 a_16416_7846.n1 GND 0.01fF
C987 a_16416_7846.n2 GND 0.00fF
C988 a_16416_7846.n3 GND 0.00fF
C989 a_16416_7846.n4 GND 0.00fF
C990 a_16416_7846.n5 GND 0.00fF
C991 a_16416_7846.n6 GND 0.00fF
C992 a_16416_7846.n7 GND 0.00fF
C993 a_16416_7846.n8 GND 0.00fF
C994 a_16416_7846.n9 GND 0.00fF
C995 a_16416_7846.t3 GND 0.02fF $ **FLOATING
C996 a_16416_7846.t2 GND 0.02fF $ **FLOATING
C997 a_16416_7846.n10 GND 0.05fF
C998 a_16416_7846.n11 GND 0.00fF
C999 a_16416_7846.n12 GND 0.00fF
C1000 a_16416_7846.n13 GND 0.02fF
C1001 a_16416_7846.n14 GND 0.05fF
C1002 a_16416_7846.n15 GND 0.13fF
C1003 a_16416_7846.n16 GND 0.01fF
C1004 a_16416_7846.n17 GND 0.12fF
C1005 a_16416_7846.t0 GND 3.94fF $ **FLOATING
C1006 a_16416_7846.n18 GND 0.53fF
C1007 a_16416_7846.t1 GND 0.24fF $ **FLOATING
C1008 a_5456_6092.n0 GND 0.00fF
C1009 a_5456_6092.n1 GND 0.00fF
C1010 a_5456_6092.n2 GND 0.01fF
C1011 a_5456_6092.n3 GND 0.01fF
C1012 a_5456_6092.n4 GND 0.00fF
C1013 a_5456_6092.n5 GND 0.01fF
C1014 a_5456_6092.n6 GND 0.00fF
C1015 a_5456_6092.n7 GND 0.00fF
C1016 a_5456_6092.n8 GND 0.00fF
C1017 a_5456_6092.n9 GND 0.00fF
C1018 a_5456_6092.n10 GND 0.09fF
C1019 a_5456_6092.n11 GND 0.00fF
C1020 a_5456_6092.n12 GND 0.01fF
C1021 a_5456_6092.n13 GND 0.01fF
C1022 a_5456_6092.n14 GND 0.01fF
C1023 a_5456_6092.n15 GND 0.00fF
C1024 a_5456_6092.n16 GND 0.00fF
C1025 a_5456_6092.n17 GND 0.00fF
C1026 a_5456_6092.t2 GND 0.02fF $ **FLOATING
C1027 a_5456_6092.n18 GND 0.07fF
C1028 a_5456_6092.n19 GND 0.02fF
C1029 a_5456_6092.n20 GND 0.05fF
C1030 a_5456_6092.n22 GND 0.04fF
C1031 a_5456_6092.n23 GND 0.04fF
C1032 a_5456_6092.n24 GND 0.00fF
C1033 a_5456_6092.n25 GND 0.00fF
C1034 a_5456_6092.t1 GND 0.02fF $ **FLOATING
C1035 a_5456_6092.n26 GND 0.07fF
C1036 a_5456_6092.n27 GND 0.02fF
C1037 a_5456_6092.n28 GND 0.05fF
C1038 a_5456_6092.n30 GND 0.01fF
C1039 a_5456_6092.n31 GND 0.00fF
C1040 a_5456_6092.n32 GND 0.01fF
C1041 a_5456_6092.n33 GND 0.00fF
C1042 a_5456_6092.n34 GND 0.00fF
C1043 a_5456_6092.n35 GND 0.00fF
C1044 a_5456_6092.n36 GND 0.00fF
C1045 a_5456_6092.n38 GND 0.08fF
C1046 a_5456_6092.t3 GND 4.25fF $ **FLOATING
C1047 a_5456_6092.n39 GND 0.62fF
C1048 a_5456_6092.t0 GND 0.26fF $ **FLOATING
C1049 a_27666_9676.n0 GND 0.01fF
C1050 a_27666_9676.n1 GND 0.01fF
C1051 a_27666_9676.n2 GND 0.00fF
C1052 a_27666_9676.n3 GND 0.00fF
C1053 a_27666_9676.n4 GND 0.00fF
C1054 a_27666_9676.n5 GND 0.00fF
C1055 a_27666_9676.n6 GND 0.00fF
C1056 a_27666_9676.n7 GND 0.00fF
C1057 a_27666_9676.n8 GND 0.00fF
C1058 a_27666_9676.n9 GND 0.00fF
C1059 a_27666_9676.t2 GND 0.02fF $ **FLOATING
C1060 a_27666_9676.t3 GND 0.02fF $ **FLOATING
C1061 a_27666_9676.n10 GND 0.05fF
C1062 a_27666_9676.n11 GND 0.00fF
C1063 a_27666_9676.n12 GND 0.00fF
C1064 a_27666_9676.n13 GND 0.02fF
C1065 a_27666_9676.n14 GND 0.05fF
C1066 a_27666_9676.n15 GND 0.13fF
C1067 a_27666_9676.n16 GND 0.01fF
C1068 a_27666_9676.n17 GND 0.12fF
C1069 a_27666_9676.t1 GND 3.94fF $ **FLOATING
C1070 a_27666_9676.n18 GND 0.53fF
C1071 a_27666_9676.t0 GND 0.24fF $ **FLOATING
C1072 a_27956_9752.n0 GND 0.00fF
C1073 a_27956_9752.n1 GND 0.00fF
C1074 a_27956_9752.n2 GND 0.01fF
C1075 a_27956_9752.n3 GND 0.01fF
C1076 a_27956_9752.n4 GND 0.00fF
C1077 a_27956_9752.n5 GND 0.01fF
C1078 a_27956_9752.n6 GND 0.00fF
C1079 a_27956_9752.n7 GND 0.00fF
C1080 a_27956_9752.n8 GND 0.00fF
C1081 a_27956_9752.n9 GND 0.00fF
C1082 a_27956_9752.n10 GND 0.09fF
C1083 a_27956_9752.n11 GND 0.00fF
C1084 a_27956_9752.n12 GND 0.01fF
C1085 a_27956_9752.n13 GND 0.01fF
C1086 a_27956_9752.n14 GND 0.01fF
C1087 a_27956_9752.n15 GND 0.00fF
C1088 a_27956_9752.n16 GND 0.00fF
C1089 a_27956_9752.n17 GND 0.00fF
C1090 a_27956_9752.t2 GND 0.02fF $ **FLOATING
C1091 a_27956_9752.n18 GND 0.07fF
C1092 a_27956_9752.n19 GND 0.02fF
C1093 a_27956_9752.n20 GND 0.05fF
C1094 a_27956_9752.n22 GND 0.04fF
C1095 a_27956_9752.n23 GND 0.04fF
C1096 a_27956_9752.n24 GND 0.00fF
C1097 a_27956_9752.n25 GND 0.00fF
C1098 a_27956_9752.t3 GND 0.02fF $ **FLOATING
C1099 a_27956_9752.n26 GND 0.07fF
C1100 a_27956_9752.n27 GND 0.02fF
C1101 a_27956_9752.n28 GND 0.05fF
C1102 a_27956_9752.n30 GND 0.01fF
C1103 a_27956_9752.n31 GND 0.00fF
C1104 a_27956_9752.n32 GND 0.01fF
C1105 a_27956_9752.n33 GND 0.00fF
C1106 a_27956_9752.n34 GND 0.00fF
C1107 a_27956_9752.n35 GND 0.00fF
C1108 a_27956_9752.n36 GND 0.00fF
C1109 a_27956_9752.n38 GND 0.08fF
C1110 a_27956_9752.t1 GND 4.25fF $ **FLOATING
C1111 a_27956_9752.n39 GND 0.62fF
C1112 a_27956_9752.t0 GND 0.26fF $ **FLOATING
C1113 a_24206_2432.n0 GND 0.00fF
C1114 a_24206_2432.n1 GND 0.00fF
C1115 a_24206_2432.n2 GND 0.01fF
C1116 a_24206_2432.n3 GND 0.01fF
C1117 a_24206_2432.n4 GND 0.00fF
C1118 a_24206_2432.n5 GND 0.01fF
C1119 a_24206_2432.n6 GND 0.00fF
C1120 a_24206_2432.n7 GND 0.00fF
C1121 a_24206_2432.n8 GND 0.00fF
C1122 a_24206_2432.n9 GND 0.00fF
C1123 a_24206_2432.n10 GND 0.09fF
C1124 a_24206_2432.n11 GND 0.00fF
C1125 a_24206_2432.n12 GND 0.01fF
C1126 a_24206_2432.n13 GND 0.01fF
C1127 a_24206_2432.n14 GND 0.01fF
C1128 a_24206_2432.n15 GND 0.00fF
C1129 a_24206_2432.n16 GND 0.00fF
C1130 a_24206_2432.n17 GND 0.00fF
C1131 a_24206_2432.t1 GND 0.02fF $ **FLOATING
C1132 a_24206_2432.n18 GND 0.07fF
C1133 a_24206_2432.n19 GND 0.02fF
C1134 a_24206_2432.n20 GND 0.05fF
C1135 a_24206_2432.n22 GND 0.04fF
C1136 a_24206_2432.n23 GND 0.04fF
C1137 a_24206_2432.n24 GND 0.00fF
C1138 a_24206_2432.n25 GND 0.00fF
C1139 a_24206_2432.t2 GND 0.02fF $ **FLOATING
C1140 a_24206_2432.n26 GND 0.07fF
C1141 a_24206_2432.n27 GND 0.02fF
C1142 a_24206_2432.n28 GND 0.05fF
C1143 a_24206_2432.n30 GND 0.01fF
C1144 a_24206_2432.n31 GND 0.00fF
C1145 a_24206_2432.n32 GND 0.01fF
C1146 a_24206_2432.n33 GND 0.00fF
C1147 a_24206_2432.n34 GND 0.00fF
C1148 a_24206_2432.n35 GND 0.00fF
C1149 a_24206_2432.n36 GND 0.00fF
C1150 a_24206_2432.n38 GND 0.08fF
C1151 a_24206_2432.t3 GND 4.25fF $ **FLOATING
C1152 a_24206_2432.n39 GND 0.62fF
C1153 a_24206_2432.t0 GND 0.26fF $ **FLOATING
C1154 a_1416_6016.n0 GND 0.01fF
C1155 a_1416_6016.n1 GND 0.01fF
C1156 a_1416_6016.n2 GND 0.00fF
C1157 a_1416_6016.n3 GND 0.00fF
C1158 a_1416_6016.n4 GND 0.00fF
C1159 a_1416_6016.n5 GND 0.00fF
C1160 a_1416_6016.n6 GND 0.00fF
C1161 a_1416_6016.n7 GND 0.00fF
C1162 a_1416_6016.n8 GND 0.00fF
C1163 a_1416_6016.n9 GND 0.00fF
C1164 a_1416_6016.t3 GND 0.02fF $ **FLOATING
C1165 a_1416_6016.t2 GND 0.02fF $ **FLOATING
C1166 a_1416_6016.n10 GND 0.05fF
C1167 a_1416_6016.n11 GND 0.00fF
C1168 a_1416_6016.n12 GND 0.00fF
C1169 a_1416_6016.n13 GND 0.02fF
C1170 a_1416_6016.n14 GND 0.05fF
C1171 a_1416_6016.n15 GND 0.13fF
C1172 a_1416_6016.n16 GND 0.01fF
C1173 a_1416_6016.n17 GND 0.12fF
C1174 a_1416_6016.t0 GND 3.94fF $ **FLOATING
C1175 a_1416_6016.n18 GND 0.53fF
C1176 a_1416_6016.t1 GND 0.24fF $ **FLOATING
C1177 a_20166_11506.n0 GND 0.01fF
C1178 a_20166_11506.n1 GND 0.01fF
C1179 a_20166_11506.n2 GND 0.00fF
C1180 a_20166_11506.n3 GND 0.00fF
C1181 a_20166_11506.n4 GND 0.00fF
C1182 a_20166_11506.n5 GND 0.00fF
C1183 a_20166_11506.n6 GND 0.00fF
C1184 a_20166_11506.n7 GND 0.00fF
C1185 a_20166_11506.n8 GND 0.00fF
C1186 a_20166_11506.n9 GND 0.00fF
C1187 a_20166_11506.t2 GND 0.02fF $ **FLOATING
C1188 a_20166_11506.t3 GND 0.02fF $ **FLOATING
C1189 a_20166_11506.n10 GND 0.05fF
C1190 a_20166_11506.n11 GND 0.00fF
C1191 a_20166_11506.n12 GND 0.00fF
C1192 a_20166_11506.n13 GND 0.02fF
C1193 a_20166_11506.n14 GND 0.05fF
C1194 a_20166_11506.n15 GND 0.13fF
C1195 a_20166_11506.n16 GND 0.01fF
C1196 a_20166_11506.n17 GND 0.12fF
C1197 a_20166_11506.t1 GND 3.94fF $ **FLOATING
C1198 a_20166_11506.n18 GND 0.53fF
C1199 a_20166_11506.t0 GND 0.24fF $ **FLOATING
C1200 a_9206_4262.n0 GND 0.00fF
C1201 a_9206_4262.n1 GND 0.00fF
C1202 a_9206_4262.n2 GND 0.01fF
C1203 a_9206_4262.n3 GND 0.01fF
C1204 a_9206_4262.n4 GND 0.00fF
C1205 a_9206_4262.n5 GND 0.01fF
C1206 a_9206_4262.n6 GND 0.00fF
C1207 a_9206_4262.n7 GND 0.00fF
C1208 a_9206_4262.n8 GND 0.00fF
C1209 a_9206_4262.n9 GND 0.00fF
C1210 a_9206_4262.n10 GND 0.09fF
C1211 a_9206_4262.n11 GND 0.00fF
C1212 a_9206_4262.n12 GND 0.01fF
C1213 a_9206_4262.n13 GND 0.01fF
C1214 a_9206_4262.n14 GND 0.01fF
C1215 a_9206_4262.n15 GND 0.00fF
C1216 a_9206_4262.n16 GND 0.00fF
C1217 a_9206_4262.n17 GND 0.00fF
C1218 a_9206_4262.t1 GND 0.02fF $ **FLOATING
C1219 a_9206_4262.n18 GND 0.07fF
C1220 a_9206_4262.n19 GND 0.02fF
C1221 a_9206_4262.n20 GND 0.05fF
C1222 a_9206_4262.n22 GND 0.04fF
C1223 a_9206_4262.n23 GND 0.04fF
C1224 a_9206_4262.n24 GND 0.00fF
C1225 a_9206_4262.n25 GND 0.00fF
C1226 a_9206_4262.t2 GND 0.02fF $ **FLOATING
C1227 a_9206_4262.n26 GND 0.07fF
C1228 a_9206_4262.n27 GND 0.02fF
C1229 a_9206_4262.n28 GND 0.05fF
C1230 a_9206_4262.n30 GND 0.01fF
C1231 a_9206_4262.n31 GND 0.00fF
C1232 a_9206_4262.n32 GND 0.01fF
C1233 a_9206_4262.n33 GND 0.00fF
C1234 a_9206_4262.n34 GND 0.00fF
C1235 a_9206_4262.n35 GND 0.00fF
C1236 a_9206_4262.n36 GND 0.00fF
C1237 a_9206_4262.n38 GND 0.08fF
C1238 a_9206_4262.t3 GND 4.25fF $ **FLOATING
C1239 a_9206_4262.n39 GND 0.62fF
C1240 a_9206_4262.t0 GND 0.26fF $ **FLOATING
C1241 a_20166_2356.n0 GND 0.01fF
C1242 a_20166_2356.n1 GND 0.01fF
C1243 a_20166_2356.n2 GND 0.00fF
C1244 a_20166_2356.n3 GND 0.00fF
C1245 a_20166_2356.n4 GND 0.00fF
C1246 a_20166_2356.n5 GND 0.00fF
C1247 a_20166_2356.n6 GND 0.00fF
C1248 a_20166_2356.n7 GND 0.00fF
C1249 a_20166_2356.n8 GND 0.00fF
C1250 a_20166_2356.n9 GND 0.00fF
C1251 a_20166_2356.t2 GND 0.02fF $ **FLOATING
C1252 a_20166_2356.t3 GND 0.02fF $ **FLOATING
C1253 a_20166_2356.n10 GND 0.05fF
C1254 a_20166_2356.n11 GND 0.00fF
C1255 a_20166_2356.n12 GND 0.00fF
C1256 a_20166_2356.n13 GND 0.02fF
C1257 a_20166_2356.n14 GND 0.05fF
C1258 a_20166_2356.n15 GND 0.13fF
C1259 a_20166_2356.n16 GND 0.01fF
C1260 a_20166_2356.n17 GND 0.12fF
C1261 a_20166_2356.t0 GND 3.94fF $ **FLOATING
C1262 a_20166_2356.n18 GND 0.53fF
C1263 a_20166_2356.t1 GND 0.24fF $ **FLOATING
C1264 a_5456_2432.n0 GND 0.00fF
C1265 a_5456_2432.n1 GND 0.00fF
C1266 a_5456_2432.n2 GND 0.01fF
C1267 a_5456_2432.n3 GND 0.01fF
C1268 a_5456_2432.n4 GND 0.00fF
C1269 a_5456_2432.n5 GND 0.01fF
C1270 a_5456_2432.n6 GND 0.00fF
C1271 a_5456_2432.n7 GND 0.00fF
C1272 a_5456_2432.n8 GND 0.00fF
C1273 a_5456_2432.n9 GND 0.00fF
C1274 a_5456_2432.n10 GND 0.09fF
C1275 a_5456_2432.n11 GND 0.00fF
C1276 a_5456_2432.n12 GND 0.01fF
C1277 a_5456_2432.n13 GND 0.01fF
C1278 a_5456_2432.n14 GND 0.01fF
C1279 a_5456_2432.n15 GND 0.00fF
C1280 a_5456_2432.n16 GND 0.00fF
C1281 a_5456_2432.n17 GND 0.00fF
C1282 a_5456_2432.t2 GND 0.02fF $ **FLOATING
C1283 a_5456_2432.n18 GND 0.07fF
C1284 a_5456_2432.n19 GND 0.02fF
C1285 a_5456_2432.n20 GND 0.05fF
C1286 a_5456_2432.n22 GND 0.04fF
C1287 a_5456_2432.n23 GND 0.04fF
C1288 a_5456_2432.n24 GND 0.00fF
C1289 a_5456_2432.n25 GND 0.00fF
C1290 a_5456_2432.t1 GND 0.02fF $ **FLOATING
C1291 a_5456_2432.n26 GND 0.07fF
C1292 a_5456_2432.n27 GND 0.02fF
C1293 a_5456_2432.n28 GND 0.05fF
C1294 a_5456_2432.n30 GND 0.01fF
C1295 a_5456_2432.n31 GND 0.00fF
C1296 a_5456_2432.n32 GND 0.01fF
C1297 a_5456_2432.n33 GND 0.00fF
C1298 a_5456_2432.n34 GND 0.00fF
C1299 a_5456_2432.n35 GND 0.00fF
C1300 a_5456_2432.n36 GND 0.00fF
C1301 a_5456_2432.n38 GND 0.08fF
C1302 a_5456_2432.t3 GND 4.25fF $ **FLOATING
C1303 a_5456_2432.n39 GND 0.62fF
C1304 a_5456_2432.t0 GND 0.26fF $ **FLOATING
C1305 a_1416_2356.n0 GND 0.01fF
C1306 a_1416_2356.n1 GND 0.01fF
C1307 a_1416_2356.n2 GND 0.00fF
C1308 a_1416_2356.n3 GND 0.00fF
C1309 a_1416_2356.n4 GND 0.00fF
C1310 a_1416_2356.n5 GND 0.00fF
C1311 a_1416_2356.n6 GND 0.00fF
C1312 a_1416_2356.n7 GND 0.00fF
C1313 a_1416_2356.n8 GND 0.00fF
C1314 a_1416_2356.n9 GND 0.00fF
C1315 a_1416_2356.t3 GND 0.02fF $ **FLOATING
C1316 a_1416_2356.t2 GND 0.02fF $ **FLOATING
C1317 a_1416_2356.n10 GND 0.05fF
C1318 a_1416_2356.n11 GND 0.00fF
C1319 a_1416_2356.n12 GND 0.00fF
C1320 a_1416_2356.n13 GND 0.02fF
C1321 a_1416_2356.n14 GND 0.05fF
C1322 a_1416_2356.n15 GND 0.13fF
C1323 a_1416_2356.n16 GND 0.01fF
C1324 a_1416_2356.n17 GND 0.12fF
C1325 a_1416_2356.t0 GND 3.94fF $ **FLOATING
C1326 a_1416_2356.n18 GND 0.53fF
C1327 a_1416_2356.t1 GND 0.24fF $ **FLOATING
C1328 a_16706_11582.n0 GND 0.00fF
C1329 a_16706_11582.n1 GND 0.00fF
C1330 a_16706_11582.n2 GND 0.01fF
C1331 a_16706_11582.n3 GND 0.01fF
C1332 a_16706_11582.n4 GND 0.00fF
C1333 a_16706_11582.n5 GND 0.01fF
C1334 a_16706_11582.n6 GND 0.00fF
C1335 a_16706_11582.n7 GND 0.00fF
C1336 a_16706_11582.n8 GND 0.00fF
C1337 a_16706_11582.n9 GND 0.00fF
C1338 a_16706_11582.n10 GND 0.09fF
C1339 a_16706_11582.n11 GND 0.00fF
C1340 a_16706_11582.n12 GND 0.01fF
C1341 a_16706_11582.n13 GND 0.01fF
C1342 a_16706_11582.n14 GND 0.01fF
C1343 a_16706_11582.n15 GND 0.00fF
C1344 a_16706_11582.n16 GND 0.00fF
C1345 a_16706_11582.n17 GND 0.00fF
C1346 a_16706_11582.t0 GND 0.02fF $ **FLOATING
C1347 a_16706_11582.n18 GND 0.07fF
C1348 a_16706_11582.n19 GND 0.02fF
C1349 a_16706_11582.n20 GND 0.05fF
C1350 a_16706_11582.n22 GND 0.04fF
C1351 a_16706_11582.n23 GND 0.04fF
C1352 a_16706_11582.n24 GND 0.00fF
C1353 a_16706_11582.n25 GND 0.00fF
C1354 a_16706_11582.t1 GND 0.02fF $ **FLOATING
C1355 a_16706_11582.n26 GND 0.07fF
C1356 a_16706_11582.n27 GND 0.02fF
C1357 a_16706_11582.n28 GND 0.05fF
C1358 a_16706_11582.n30 GND 0.01fF
C1359 a_16706_11582.n31 GND 0.00fF
C1360 a_16706_11582.n32 GND 0.01fF
C1361 a_16706_11582.n33 GND 0.00fF
C1362 a_16706_11582.n34 GND 0.00fF
C1363 a_16706_11582.n35 GND 0.00fF
C1364 a_16706_11582.n36 GND 0.00fF
C1365 a_16706_11582.n38 GND 0.08fF
C1366 a_16706_11582.t3 GND 4.25fF $ **FLOATING
C1367 a_16706_11582.n39 GND 0.62fF
C1368 a_16706_11582.t2 GND 0.26fF $ **FLOATING
C1369 a_8916_11506.n0 GND 0.01fF
C1370 a_8916_11506.n1 GND 0.01fF
C1371 a_8916_11506.n2 GND 0.00fF
C1372 a_8916_11506.n3 GND 0.00fF
C1373 a_8916_11506.n4 GND 0.00fF
C1374 a_8916_11506.n5 GND 0.00fF
C1375 a_8916_11506.n6 GND 0.00fF
C1376 a_8916_11506.n7 GND 0.00fF
C1377 a_8916_11506.n8 GND 0.00fF
C1378 a_8916_11506.n9 GND 0.00fF
C1379 a_8916_11506.t2 GND 0.02fF $ **FLOATING
C1380 a_8916_11506.t3 GND 0.02fF $ **FLOATING
C1381 a_8916_11506.n10 GND 0.05fF
C1382 a_8916_11506.n11 GND 0.00fF
C1383 a_8916_11506.n12 GND 0.00fF
C1384 a_8916_11506.n13 GND 0.02fF
C1385 a_8916_11506.n14 GND 0.05fF
C1386 a_8916_11506.n15 GND 0.13fF
C1387 a_8916_11506.n16 GND 0.01fF
C1388 a_8916_11506.n17 GND 0.12fF
C1389 a_8916_11506.t1 GND 3.94fF $ **FLOATING
C1390 a_8916_11506.n18 GND 0.53fF
C1391 a_8916_11506.t0 GND 0.24fF $ **FLOATING
C1392 a_5456_9752.n0 GND 0.00fF
C1393 a_5456_9752.n1 GND 0.00fF
C1394 a_5456_9752.n2 GND 0.01fF
C1395 a_5456_9752.n3 GND 0.01fF
C1396 a_5456_9752.n4 GND 0.00fF
C1397 a_5456_9752.n5 GND 0.01fF
C1398 a_5456_9752.n6 GND 0.00fF
C1399 a_5456_9752.n7 GND 0.00fF
C1400 a_5456_9752.n8 GND 0.00fF
C1401 a_5456_9752.n9 GND 0.00fF
C1402 a_5456_9752.n10 GND 0.09fF
C1403 a_5456_9752.n11 GND 0.00fF
C1404 a_5456_9752.n12 GND 0.01fF
C1405 a_5456_9752.n13 GND 0.01fF
C1406 a_5456_9752.n14 GND 0.01fF
C1407 a_5456_9752.n15 GND 0.00fF
C1408 a_5456_9752.n16 GND 0.00fF
C1409 a_5456_9752.n17 GND 0.00fF
C1410 a_5456_9752.t3 GND 0.02fF $ **FLOATING
C1411 a_5456_9752.n18 GND 0.07fF
C1412 a_5456_9752.n19 GND 0.02fF
C1413 a_5456_9752.n20 GND 0.05fF
C1414 a_5456_9752.n22 GND 0.04fF
C1415 a_5456_9752.n23 GND 0.04fF
C1416 a_5456_9752.n24 GND 0.00fF
C1417 a_5456_9752.n25 GND 0.00fF
C1418 a_5456_9752.t2 GND 0.02fF $ **FLOATING
C1419 a_5456_9752.n26 GND 0.07fF
C1420 a_5456_9752.n27 GND 0.02fF
C1421 a_5456_9752.n28 GND 0.05fF
C1422 a_5456_9752.n30 GND 0.01fF
C1423 a_5456_9752.n31 GND 0.00fF
C1424 a_5456_9752.n32 GND 0.01fF
C1425 a_5456_9752.n33 GND 0.00fF
C1426 a_5456_9752.n34 GND 0.00fF
C1427 a_5456_9752.n35 GND 0.00fF
C1428 a_5456_9752.n36 GND 0.00fF
C1429 a_5456_9752.n38 GND 0.08fF
C1430 a_5456_9752.t1 GND 4.25fF $ **FLOATING
C1431 a_5456_9752.n39 GND 0.62fF
C1432 a_5456_9752.t0 GND 0.26fF $ **FLOATING
C1433 a_20166_4186.n0 GND 0.01fF
C1434 a_20166_4186.n1 GND 0.01fF
C1435 a_20166_4186.n2 GND 0.00fF
C1436 a_20166_4186.n3 GND 0.00fF
C1437 a_20166_4186.n4 GND 0.00fF
C1438 a_20166_4186.n5 GND 0.00fF
C1439 a_20166_4186.n6 GND 0.00fF
C1440 a_20166_4186.n7 GND 0.00fF
C1441 a_20166_4186.n8 GND 0.00fF
C1442 a_20166_4186.n9 GND 0.00fF
C1443 a_20166_4186.t2 GND 0.02fF $ **FLOATING
C1444 a_20166_4186.t3 GND 0.02fF $ **FLOATING
C1445 a_20166_4186.n10 GND 0.05fF
C1446 a_20166_4186.n11 GND 0.00fF
C1447 a_20166_4186.n12 GND 0.00fF
C1448 a_20166_4186.n13 GND 0.02fF
C1449 a_20166_4186.n14 GND 0.05fF
C1450 a_20166_4186.n15 GND 0.13fF
C1451 a_20166_4186.n16 GND 0.01fF
C1452 a_20166_4186.n17 GND 0.12fF
C1453 a_20166_4186.t1 GND 3.94fF $ **FLOATING
C1454 a_20166_4186.n18 GND 0.53fF
C1455 a_20166_4186.t0 GND 0.24fF $ **FLOATING
C1456 a_1706_6092.n0 GND 0.00fF
C1457 a_1706_6092.n1 GND 0.00fF
C1458 a_1706_6092.n2 GND 0.01fF
C1459 a_1706_6092.n3 GND 0.01fF
C1460 a_1706_6092.n4 GND 0.00fF
C1461 a_1706_6092.n5 GND 0.01fF
C1462 a_1706_6092.n6 GND 0.00fF
C1463 a_1706_6092.n7 GND 0.00fF
C1464 a_1706_6092.n8 GND 0.00fF
C1465 a_1706_6092.n9 GND 0.00fF
C1466 a_1706_6092.n10 GND 0.09fF
C1467 a_1706_6092.n11 GND 0.00fF
C1468 a_1706_6092.n12 GND 0.01fF
C1469 a_1706_6092.n13 GND 0.01fF
C1470 a_1706_6092.n14 GND 0.01fF
C1471 a_1706_6092.n15 GND 0.00fF
C1472 a_1706_6092.n16 GND 0.00fF
C1473 a_1706_6092.n17 GND 0.00fF
C1474 a_1706_6092.t2 GND 0.02fF $ **FLOATING
C1475 a_1706_6092.n18 GND 0.07fF
C1476 a_1706_6092.n19 GND 0.02fF
C1477 a_1706_6092.n20 GND 0.05fF
C1478 a_1706_6092.n22 GND 0.04fF
C1479 a_1706_6092.n23 GND 0.04fF
C1480 a_1706_6092.n24 GND 0.00fF
C1481 a_1706_6092.n25 GND 0.00fF
C1482 a_1706_6092.t1 GND 0.02fF $ **FLOATING
C1483 a_1706_6092.n26 GND 0.07fF
C1484 a_1706_6092.n27 GND 0.02fF
C1485 a_1706_6092.n28 GND 0.05fF
C1486 a_1706_6092.n30 GND 0.01fF
C1487 a_1706_6092.n31 GND 0.00fF
C1488 a_1706_6092.n32 GND 0.01fF
C1489 a_1706_6092.n33 GND 0.00fF
C1490 a_1706_6092.n34 GND 0.00fF
C1491 a_1706_6092.n35 GND 0.00fF
C1492 a_1706_6092.n36 GND 0.00fF
C1493 a_1706_6092.n38 GND 0.08fF
C1494 a_1706_6092.t3 GND 4.25fF $ **FLOATING
C1495 a_1706_6092.n39 GND 0.62fF
C1496 a_1706_6092.t0 GND 0.26fF $ **FLOATING
C1497 a_1706_2432.n0 GND 0.00fF
C1498 a_1706_2432.n1 GND 0.00fF
C1499 a_1706_2432.n2 GND 0.01fF
C1500 a_1706_2432.n3 GND 0.01fF
C1501 a_1706_2432.n4 GND 0.00fF
C1502 a_1706_2432.n5 GND 0.01fF
C1503 a_1706_2432.n6 GND 0.00fF
C1504 a_1706_2432.n7 GND 0.00fF
C1505 a_1706_2432.n8 GND 0.00fF
C1506 a_1706_2432.n9 GND 0.00fF
C1507 a_1706_2432.n10 GND 0.09fF
C1508 a_1706_2432.n11 GND 0.00fF
C1509 a_1706_2432.n12 GND 0.01fF
C1510 a_1706_2432.n13 GND 0.01fF
C1511 a_1706_2432.n14 GND 0.01fF
C1512 a_1706_2432.n15 GND 0.00fF
C1513 a_1706_2432.n16 GND 0.00fF
C1514 a_1706_2432.n17 GND 0.00fF
C1515 a_1706_2432.t2 GND 0.02fF $ **FLOATING
C1516 a_1706_2432.n18 GND 0.07fF
C1517 a_1706_2432.n19 GND 0.02fF
C1518 a_1706_2432.n20 GND 0.05fF
C1519 a_1706_2432.n22 GND 0.04fF
C1520 a_1706_2432.n23 GND 0.04fF
C1521 a_1706_2432.n24 GND 0.00fF
C1522 a_1706_2432.n25 GND 0.00fF
C1523 a_1706_2432.t1 GND 0.02fF $ **FLOATING
C1524 a_1706_2432.n26 GND 0.07fF
C1525 a_1706_2432.n27 GND 0.02fF
C1526 a_1706_2432.n28 GND 0.05fF
C1527 a_1706_2432.n30 GND 0.01fF
C1528 a_1706_2432.n31 GND 0.00fF
C1529 a_1706_2432.n32 GND 0.01fF
C1530 a_1706_2432.n33 GND 0.00fF
C1531 a_1706_2432.n34 GND 0.00fF
C1532 a_1706_2432.n35 GND 0.00fF
C1533 a_1706_2432.n36 GND 0.00fF
C1534 a_1706_2432.n38 GND 0.08fF
C1535 a_1706_2432.t3 GND 4.25fF $ **FLOATING
C1536 a_1706_2432.n39 GND 0.62fF
C1537 a_1706_2432.t0 GND 0.26fF $ **FLOATING
C1538 a_9206_6092.n0 GND 0.00fF
C1539 a_9206_6092.n1 GND 0.00fF
C1540 a_9206_6092.n2 GND 0.01fF
C1541 a_9206_6092.n3 GND 0.01fF
C1542 a_9206_6092.n4 GND 0.00fF
C1543 a_9206_6092.n5 GND 0.01fF
C1544 a_9206_6092.n6 GND 0.00fF
C1545 a_9206_6092.n7 GND 0.00fF
C1546 a_9206_6092.n8 GND 0.00fF
C1547 a_9206_6092.n9 GND 0.00fF
C1548 a_9206_6092.n10 GND 0.09fF
C1549 a_9206_6092.n11 GND 0.00fF
C1550 a_9206_6092.n12 GND 0.01fF
C1551 a_9206_6092.n13 GND 0.01fF
C1552 a_9206_6092.n14 GND 0.01fF
C1553 a_9206_6092.n15 GND 0.00fF
C1554 a_9206_6092.n16 GND 0.00fF
C1555 a_9206_6092.n17 GND 0.00fF
C1556 a_9206_6092.t1 GND 0.02fF $ **FLOATING
C1557 a_9206_6092.n18 GND 0.07fF
C1558 a_9206_6092.n19 GND 0.02fF
C1559 a_9206_6092.n20 GND 0.05fF
C1560 a_9206_6092.n22 GND 0.04fF
C1561 a_9206_6092.n23 GND 0.04fF
C1562 a_9206_6092.n24 GND 0.00fF
C1563 a_9206_6092.n25 GND 0.00fF
C1564 a_9206_6092.t2 GND 0.02fF $ **FLOATING
C1565 a_9206_6092.n26 GND 0.07fF
C1566 a_9206_6092.n27 GND 0.02fF
C1567 a_9206_6092.n28 GND 0.05fF
C1568 a_9206_6092.n30 GND 0.01fF
C1569 a_9206_6092.n31 GND 0.00fF
C1570 a_9206_6092.n32 GND 0.01fF
C1571 a_9206_6092.n33 GND 0.00fF
C1572 a_9206_6092.n34 GND 0.00fF
C1573 a_9206_6092.n35 GND 0.00fF
C1574 a_9206_6092.n36 GND 0.00fF
C1575 a_9206_6092.n38 GND 0.08fF
C1576 a_9206_6092.t3 GND 4.25fF $ **FLOATING
C1577 a_9206_6092.n39 GND 0.62fF
C1578 a_9206_6092.t0 GND 0.26fF $ **FLOATING
C1579 a_8916_6016.n0 GND 0.01fF
C1580 a_8916_6016.n1 GND 0.01fF
C1581 a_8916_6016.n2 GND 0.00fF
C1582 a_8916_6016.n3 GND 0.00fF
C1583 a_8916_6016.n4 GND 0.00fF
C1584 a_8916_6016.n5 GND 0.00fF
C1585 a_8916_6016.n6 GND 0.00fF
C1586 a_8916_6016.n7 GND 0.00fF
C1587 a_8916_6016.n8 GND 0.00fF
C1588 a_8916_6016.n9 GND 0.00fF
C1589 a_8916_6016.t3 GND 0.02fF $ **FLOATING
C1590 a_8916_6016.t2 GND 0.02fF $ **FLOATING
C1591 a_8916_6016.n10 GND 0.05fF
C1592 a_8916_6016.n11 GND 0.00fF
C1593 a_8916_6016.n12 GND 0.00fF
C1594 a_8916_6016.n13 GND 0.02fF
C1595 a_8916_6016.n14 GND 0.05fF
C1596 a_8916_6016.n15 GND 0.13fF
C1597 a_8916_6016.n16 GND 0.01fF
C1598 a_8916_6016.n17 GND 0.12fF
C1599 a_8916_6016.t0 GND 3.94fF $ **FLOATING
C1600 a_8916_6016.n18 GND 0.53fF
C1601 a_8916_6016.t1 GND 0.24fF $ **FLOATING
C1602 a_20166_9676.n0 GND 0.01fF
C1603 a_20166_9676.n1 GND 0.01fF
C1604 a_20166_9676.n2 GND 0.00fF
C1605 a_20166_9676.n3 GND 0.00fF
C1606 a_20166_9676.n4 GND 0.00fF
C1607 a_20166_9676.n5 GND 0.00fF
C1608 a_20166_9676.n6 GND 0.00fF
C1609 a_20166_9676.n7 GND 0.00fF
C1610 a_20166_9676.n8 GND 0.00fF
C1611 a_20166_9676.n9 GND 0.00fF
C1612 a_20166_9676.t2 GND 0.02fF $ **FLOATING
C1613 a_20166_9676.t3 GND 0.02fF $ **FLOATING
C1614 a_20166_9676.n10 GND 0.05fF
C1615 a_20166_9676.n11 GND 0.00fF
C1616 a_20166_9676.n12 GND 0.00fF
C1617 a_20166_9676.n13 GND 0.02fF
C1618 a_20166_9676.n14 GND 0.05fF
C1619 a_20166_9676.n15 GND 0.13fF
C1620 a_20166_9676.n16 GND 0.01fF
C1621 a_20166_9676.n17 GND 0.12fF
C1622 a_20166_9676.t0 GND 3.94fF $ **FLOATING
C1623 a_20166_9676.n18 GND 0.53fF
C1624 a_20166_9676.t1 GND 0.24fF $ **FLOATING
C1625 a_23916_11506.n0 GND 0.01fF
C1626 a_23916_11506.n1 GND 0.01fF
C1627 a_23916_11506.n2 GND 0.00fF
C1628 a_23916_11506.n3 GND 0.00fF
C1629 a_23916_11506.n4 GND 0.00fF
C1630 a_23916_11506.n5 GND 0.00fF
C1631 a_23916_11506.n6 GND 0.00fF
C1632 a_23916_11506.n7 GND 0.00fF
C1633 a_23916_11506.n8 GND 0.00fF
C1634 a_23916_11506.n9 GND 0.00fF
C1635 a_23916_11506.t2 GND 0.02fF $ **FLOATING
C1636 a_23916_11506.t1 GND 0.02fF $ **FLOATING
C1637 a_23916_11506.n10 GND 0.05fF
C1638 a_23916_11506.n11 GND 0.00fF
C1639 a_23916_11506.n12 GND 0.00fF
C1640 a_23916_11506.n13 GND 0.02fF
C1641 a_23916_11506.n14 GND 0.05fF
C1642 a_23916_11506.n15 GND 0.13fF
C1643 a_23916_11506.n16 GND 0.01fF
C1644 a_23916_11506.n17 GND 0.12fF
C1645 a_23916_11506.t0 GND 3.94fF $ **FLOATING
C1646 a_23916_11506.n18 GND 0.53fF
C1647 a_23916_11506.t3 GND 0.24fF $ **FLOATING
C1648 a_27956_11582.n0 GND 0.00fF
C1649 a_27956_11582.n1 GND 0.00fF
C1650 a_27956_11582.n2 GND 0.01fF
C1651 a_27956_11582.n3 GND 0.01fF
C1652 a_27956_11582.n4 GND 0.00fF
C1653 a_27956_11582.n5 GND 0.01fF
C1654 a_27956_11582.n6 GND 0.00fF
C1655 a_27956_11582.n7 GND 0.00fF
C1656 a_27956_11582.n8 GND 0.00fF
C1657 a_27956_11582.n9 GND 0.00fF
C1658 a_27956_11582.n10 GND 0.09fF
C1659 a_27956_11582.n11 GND 0.00fF
C1660 a_27956_11582.n12 GND 0.01fF
C1661 a_27956_11582.n13 GND 0.01fF
C1662 a_27956_11582.n14 GND 0.01fF
C1663 a_27956_11582.n15 GND 0.00fF
C1664 a_27956_11582.n16 GND 0.00fF
C1665 a_27956_11582.n17 GND 0.00fF
C1666 a_27956_11582.t0 GND 0.02fF $ **FLOATING
C1667 a_27956_11582.n18 GND 0.07fF
C1668 a_27956_11582.n19 GND 0.02fF
C1669 a_27956_11582.n20 GND 0.05fF
C1670 a_27956_11582.n22 GND 0.04fF
C1671 a_27956_11582.n23 GND 0.04fF
C1672 a_27956_11582.n24 GND 0.00fF
C1673 a_27956_11582.n25 GND 0.00fF
C1674 a_27956_11582.t1 GND 0.02fF $ **FLOATING
C1675 a_27956_11582.n26 GND 0.07fF
C1676 a_27956_11582.n27 GND 0.02fF
C1677 a_27956_11582.n28 GND 0.05fF
C1678 a_27956_11582.n30 GND 0.01fF
C1679 a_27956_11582.n31 GND 0.00fF
C1680 a_27956_11582.n32 GND 0.01fF
C1681 a_27956_11582.n33 GND 0.00fF
C1682 a_27956_11582.n34 GND 0.00fF
C1683 a_27956_11582.n35 GND 0.00fF
C1684 a_27956_11582.n36 GND 0.00fF
C1685 a_27956_11582.n38 GND 0.08fF
C1686 a_27956_11582.t3 GND 4.25fF $ **FLOATING
C1687 a_27956_11582.n39 GND 0.62fF
C1688 a_27956_11582.t2 GND 0.26fF $ **FLOATING
C1689 a_12666_4186.n0 GND 0.01fF
C1690 a_12666_4186.n1 GND 0.01fF
C1691 a_12666_4186.n2 GND 0.00fF
C1692 a_12666_4186.n3 GND 0.00fF
C1693 a_12666_4186.n4 GND 0.00fF
C1694 a_12666_4186.n5 GND 0.00fF
C1695 a_12666_4186.n6 GND 0.00fF
C1696 a_12666_4186.n7 GND 0.00fF
C1697 a_12666_4186.n8 GND 0.00fF
C1698 a_12666_4186.n9 GND 0.00fF
C1699 a_12666_4186.t2 GND 0.02fF $ **FLOATING
C1700 a_12666_4186.t3 GND 0.02fF $ **FLOATING
C1701 a_12666_4186.n10 GND 0.05fF
C1702 a_12666_4186.n11 GND 0.00fF
C1703 a_12666_4186.n12 GND 0.00fF
C1704 a_12666_4186.n13 GND 0.02fF
C1705 a_12666_4186.n14 GND 0.05fF
C1706 a_12666_4186.n15 GND 0.13fF
C1707 a_12666_4186.n16 GND 0.01fF
C1708 a_12666_4186.n17 GND 0.12fF
C1709 a_12666_4186.t0 GND 3.94fF $ **FLOATING
C1710 a_12666_4186.n18 GND 0.53fF
C1711 a_12666_4186.t1 GND 0.24fF $ **FLOATING
C1712 a_20456_7922.n0 GND 0.00fF
C1713 a_20456_7922.n1 GND 0.00fF
C1714 a_20456_7922.n2 GND 0.01fF
C1715 a_20456_7922.n3 GND 0.01fF
C1716 a_20456_7922.n4 GND 0.00fF
C1717 a_20456_7922.n5 GND 0.01fF
C1718 a_20456_7922.n6 GND 0.00fF
C1719 a_20456_7922.n7 GND 0.00fF
C1720 a_20456_7922.n8 GND 0.00fF
C1721 a_20456_7922.n9 GND 0.00fF
C1722 a_20456_7922.n10 GND 0.09fF
C1723 a_20456_7922.n11 GND 0.00fF
C1724 a_20456_7922.n12 GND 0.01fF
C1725 a_20456_7922.n13 GND 0.01fF
C1726 a_20456_7922.n14 GND 0.01fF
C1727 a_20456_7922.n15 GND 0.00fF
C1728 a_20456_7922.n16 GND 0.00fF
C1729 a_20456_7922.n17 GND 0.00fF
C1730 a_20456_7922.t3 GND 0.02fF $ **FLOATING
C1731 a_20456_7922.n18 GND 0.07fF
C1732 a_20456_7922.n19 GND 0.02fF
C1733 a_20456_7922.n20 GND 0.05fF
C1734 a_20456_7922.n22 GND 0.04fF
C1735 a_20456_7922.n23 GND 0.04fF
C1736 a_20456_7922.n24 GND 0.00fF
C1737 a_20456_7922.n25 GND 0.00fF
C1738 a_20456_7922.t2 GND 0.02fF $ **FLOATING
C1739 a_20456_7922.n26 GND 0.07fF
C1740 a_20456_7922.n27 GND 0.02fF
C1741 a_20456_7922.n28 GND 0.05fF
C1742 a_20456_7922.n30 GND 0.01fF
C1743 a_20456_7922.n31 GND 0.00fF
C1744 a_20456_7922.n32 GND 0.01fF
C1745 a_20456_7922.n33 GND 0.00fF
C1746 a_20456_7922.n34 GND 0.00fF
C1747 a_20456_7922.n35 GND 0.00fF
C1748 a_20456_7922.n36 GND 0.00fF
C1749 a_20456_7922.n38 GND 0.08fF
C1750 a_20456_7922.t1 GND 4.25fF $ **FLOATING
C1751 a_20456_7922.n39 GND 0.62fF
C1752 a_20456_7922.t0 GND 0.26fF $ **FLOATING
C1753 a_16706_7922.n0 GND 0.00fF
C1754 a_16706_7922.n1 GND 0.00fF
C1755 a_16706_7922.n2 GND 0.01fF
C1756 a_16706_7922.n3 GND 0.01fF
C1757 a_16706_7922.n4 GND 0.00fF
C1758 a_16706_7922.n5 GND 0.01fF
C1759 a_16706_7922.n6 GND 0.00fF
C1760 a_16706_7922.n7 GND 0.00fF
C1761 a_16706_7922.n8 GND 0.00fF
C1762 a_16706_7922.n9 GND 0.00fF
C1763 a_16706_7922.n10 GND 0.09fF
C1764 a_16706_7922.n11 GND 0.00fF
C1765 a_16706_7922.n12 GND 0.01fF
C1766 a_16706_7922.n13 GND 0.01fF
C1767 a_16706_7922.n14 GND 0.01fF
C1768 a_16706_7922.n15 GND 0.00fF
C1769 a_16706_7922.n16 GND 0.00fF
C1770 a_16706_7922.n17 GND 0.00fF
C1771 a_16706_7922.t2 GND 0.02fF $ **FLOATING
C1772 a_16706_7922.n18 GND 0.07fF
C1773 a_16706_7922.n19 GND 0.02fF
C1774 a_16706_7922.n20 GND 0.05fF
C1775 a_16706_7922.n22 GND 0.04fF
C1776 a_16706_7922.n23 GND 0.04fF
C1777 a_16706_7922.n24 GND 0.00fF
C1778 a_16706_7922.n25 GND 0.00fF
C1779 a_16706_7922.t3 GND 0.02fF $ **FLOATING
C1780 a_16706_7922.n26 GND 0.07fF
C1781 a_16706_7922.n27 GND 0.02fF
C1782 a_16706_7922.n28 GND 0.05fF
C1783 a_16706_7922.n30 GND 0.01fF
C1784 a_16706_7922.n31 GND 0.00fF
C1785 a_16706_7922.n32 GND 0.01fF
C1786 a_16706_7922.n33 GND 0.00fF
C1787 a_16706_7922.n34 GND 0.00fF
C1788 a_16706_7922.n35 GND 0.00fF
C1789 a_16706_7922.n36 GND 0.00fF
C1790 a_16706_7922.n38 GND 0.08fF
C1791 a_16706_7922.t1 GND 4.25fF $ **FLOATING
C1792 a_16706_7922.n39 GND 0.62fF
C1793 a_16706_7922.t0 GND 0.26fF $ **FLOATING
C1794 a_12956_4262.n0 GND 0.00fF
C1795 a_12956_4262.n1 GND 0.00fF
C1796 a_12956_4262.n2 GND 0.01fF
C1797 a_12956_4262.n3 GND 0.01fF
C1798 a_12956_4262.n4 GND 0.00fF
C1799 a_12956_4262.n5 GND 0.01fF
C1800 a_12956_4262.n6 GND 0.00fF
C1801 a_12956_4262.n7 GND 0.00fF
C1802 a_12956_4262.n8 GND 0.00fF
C1803 a_12956_4262.n9 GND 0.00fF
C1804 a_12956_4262.n10 GND 0.09fF
C1805 a_12956_4262.n11 GND 0.00fF
C1806 a_12956_4262.n12 GND 0.01fF
C1807 a_12956_4262.n13 GND 0.01fF
C1808 a_12956_4262.n14 GND 0.01fF
C1809 a_12956_4262.n15 GND 0.00fF
C1810 a_12956_4262.n16 GND 0.00fF
C1811 a_12956_4262.n17 GND 0.00fF
C1812 a_12956_4262.t2 GND 0.02fF $ **FLOATING
C1813 a_12956_4262.n18 GND 0.07fF
C1814 a_12956_4262.n19 GND 0.02fF
C1815 a_12956_4262.n20 GND 0.05fF
C1816 a_12956_4262.n22 GND 0.04fF
C1817 a_12956_4262.n23 GND 0.04fF
C1818 a_12956_4262.n24 GND 0.00fF
C1819 a_12956_4262.n25 GND 0.00fF
C1820 a_12956_4262.t1 GND 0.02fF $ **FLOATING
C1821 a_12956_4262.n26 GND 0.07fF
C1822 a_12956_4262.n27 GND 0.02fF
C1823 a_12956_4262.n28 GND 0.05fF
C1824 a_12956_4262.n30 GND 0.01fF
C1825 a_12956_4262.n31 GND 0.00fF
C1826 a_12956_4262.n32 GND 0.01fF
C1827 a_12956_4262.n33 GND 0.00fF
C1828 a_12956_4262.n34 GND 0.00fF
C1829 a_12956_4262.n35 GND 0.00fF
C1830 a_12956_4262.n36 GND 0.00fF
C1831 a_12956_4262.n38 GND 0.08fF
C1832 a_12956_4262.t3 GND 4.25fF $ **FLOATING
C1833 a_12956_4262.n39 GND 0.62fF
C1834 a_12956_4262.t0 GND 0.26fF $ **FLOATING
C1835 a_16706_602.n0 GND 0.00fF
C1836 a_16706_602.n1 GND 0.00fF
C1837 a_16706_602.n2 GND 0.01fF
C1838 a_16706_602.n3 GND 0.01fF
C1839 a_16706_602.n4 GND 0.00fF
C1840 a_16706_602.n5 GND 0.01fF
C1841 a_16706_602.n6 GND 0.00fF
C1842 a_16706_602.n7 GND 0.00fF
C1843 a_16706_602.n8 GND 0.00fF
C1844 a_16706_602.n9 GND 0.00fF
C1845 a_16706_602.n10 GND 0.09fF
C1846 a_16706_602.n11 GND 0.00fF
C1847 a_16706_602.n12 GND 0.01fF
C1848 a_16706_602.n13 GND 0.01fF
C1849 a_16706_602.n14 GND 0.01fF
C1850 a_16706_602.n15 GND 0.00fF
C1851 a_16706_602.n16 GND 0.00fF
C1852 a_16706_602.n17 GND 0.00fF
C1853 a_16706_602.t1 GND 0.02fF $ **FLOATING
C1854 a_16706_602.n18 GND 0.07fF
C1855 a_16706_602.n19 GND 0.02fF
C1856 a_16706_602.n20 GND 0.05fF
C1857 a_16706_602.n22 GND 0.04fF
C1858 a_16706_602.n23 GND 0.04fF
C1859 a_16706_602.n24 GND 0.00fF
C1860 a_16706_602.n25 GND 0.00fF
C1861 a_16706_602.t2 GND 0.02fF $ **FLOATING
C1862 a_16706_602.n26 GND 0.07fF
C1863 a_16706_602.n27 GND 0.02fF
C1864 a_16706_602.n28 GND 0.05fF
C1865 a_16706_602.n30 GND 0.01fF
C1866 a_16706_602.n31 GND 0.00fF
C1867 a_16706_602.n32 GND 0.01fF
C1868 a_16706_602.n33 GND 0.00fF
C1869 a_16706_602.n34 GND 0.00fF
C1870 a_16706_602.n35 GND 0.00fF
C1871 a_16706_602.n36 GND 0.00fF
C1872 a_16706_602.n38 GND 0.08fF
C1873 a_16706_602.t3 GND 4.25fF $ **FLOATING
C1874 a_16706_602.n39 GND 0.62fF
C1875 a_16706_602.t0 GND 0.26fF $ **FLOATING
C1876 a_16416_526.n0 GND 0.01fF
C1877 a_16416_526.n1 GND 0.01fF
C1878 a_16416_526.n2 GND 0.00fF
C1879 a_16416_526.n3 GND 0.00fF
C1880 a_16416_526.n4 GND 0.00fF
C1881 a_16416_526.n5 GND 0.00fF
C1882 a_16416_526.n6 GND 0.00fF
C1883 a_16416_526.n7 GND 0.00fF
C1884 a_16416_526.n8 GND 0.00fF
C1885 a_16416_526.n9 GND 0.00fF
C1886 a_16416_526.t3 GND 0.02fF $ **FLOATING
C1887 a_16416_526.t2 GND 0.02fF $ **FLOATING
C1888 a_16416_526.n10 GND 0.05fF
C1889 a_16416_526.n11 GND 0.00fF
C1890 a_16416_526.n12 GND 0.00fF
C1891 a_16416_526.n13 GND 0.02fF
C1892 a_16416_526.n14 GND 0.05fF
C1893 a_16416_526.n15 GND 0.13fF
C1894 a_16416_526.n16 GND 0.01fF
C1895 a_16416_526.n17 GND 0.12fF
C1896 a_16416_526.t0 GND 3.94fF $ **FLOATING
C1897 a_16416_526.n18 GND 0.53fF
C1898 a_16416_526.t1 GND 0.24fF $ **FLOATING
C1899 a_23916_6016.n0 GND 0.01fF
C1900 a_23916_6016.n1 GND 0.01fF
C1901 a_23916_6016.n2 GND 0.00fF
C1902 a_23916_6016.n3 GND 0.00fF
C1903 a_23916_6016.n4 GND 0.00fF
C1904 a_23916_6016.n5 GND 0.00fF
C1905 a_23916_6016.n6 GND 0.00fF
C1906 a_23916_6016.n7 GND 0.00fF
C1907 a_23916_6016.n8 GND 0.00fF
C1908 a_23916_6016.n9 GND 0.00fF
C1909 a_23916_6016.t3 GND 0.02fF $ **FLOATING
C1910 a_23916_6016.t2 GND 0.02fF $ **FLOATING
C1911 a_23916_6016.n10 GND 0.05fF
C1912 a_23916_6016.n11 GND 0.00fF
C1913 a_23916_6016.n12 GND 0.00fF
C1914 a_23916_6016.n13 GND 0.02fF
C1915 a_23916_6016.n14 GND 0.05fF
C1916 a_23916_6016.n15 GND 0.13fF
C1917 a_23916_6016.n16 GND 0.01fF
C1918 a_23916_6016.n17 GND 0.12fF
C1919 a_23916_6016.t1 GND 3.94fF $ **FLOATING
C1920 a_23916_6016.n18 GND 0.53fF
C1921 a_23916_6016.t0 GND 0.24fF $ **FLOATING
C1922 a_27666_11506.n0 GND 0.01fF
C1923 a_27666_11506.n1 GND 0.01fF
C1924 a_27666_11506.n2 GND 0.00fF
C1925 a_27666_11506.n3 GND 0.00fF
C1926 a_27666_11506.n4 GND 0.00fF
C1927 a_27666_11506.n5 GND 0.00fF
C1928 a_27666_11506.n6 GND 0.00fF
C1929 a_27666_11506.n7 GND 0.00fF
C1930 a_27666_11506.n8 GND 0.00fF
C1931 a_27666_11506.n9 GND 0.00fF
C1932 a_27666_11506.t2 GND 0.02fF $ **FLOATING
C1933 a_27666_11506.t1 GND 0.02fF $ **FLOATING
C1934 a_27666_11506.n10 GND 0.05fF
C1935 a_27666_11506.n11 GND 0.00fF
C1936 a_27666_11506.n12 GND 0.00fF
C1937 a_27666_11506.n13 GND 0.02fF
C1938 a_27666_11506.n14 GND 0.05fF
C1939 a_27666_11506.n15 GND 0.13fF
C1940 a_27666_11506.n16 GND 0.01fF
C1941 a_27666_11506.n17 GND 0.12fF
C1942 a_27666_11506.t0 GND 3.94fF $ **FLOATING
C1943 a_27666_11506.n18 GND 0.53fF
C1944 a_27666_11506.t3 GND 0.24fF $ **FLOATING
C1945 a_9206_9752.n0 GND 0.00fF
C1946 a_9206_9752.n1 GND 0.00fF
C1947 a_9206_9752.n2 GND 0.01fF
C1948 a_9206_9752.n3 GND 0.01fF
C1949 a_9206_9752.n4 GND 0.00fF
C1950 a_9206_9752.n5 GND 0.01fF
C1951 a_9206_9752.n6 GND 0.00fF
C1952 a_9206_9752.n7 GND 0.00fF
C1953 a_9206_9752.n8 GND 0.00fF
C1954 a_9206_9752.n9 GND 0.00fF
C1955 a_9206_9752.n10 GND 0.09fF
C1956 a_9206_9752.n11 GND 0.00fF
C1957 a_9206_9752.n12 GND 0.01fF
C1958 a_9206_9752.n13 GND 0.01fF
C1959 a_9206_9752.n14 GND 0.01fF
C1960 a_9206_9752.n15 GND 0.00fF
C1961 a_9206_9752.n16 GND 0.00fF
C1962 a_9206_9752.n17 GND 0.00fF
C1963 a_9206_9752.t2 GND 0.02fF $ **FLOATING
C1964 a_9206_9752.n18 GND 0.07fF
C1965 a_9206_9752.n19 GND 0.02fF
C1966 a_9206_9752.n20 GND 0.05fF
C1967 a_9206_9752.n22 GND 0.04fF
C1968 a_9206_9752.n23 GND 0.04fF
C1969 a_9206_9752.n24 GND 0.00fF
C1970 a_9206_9752.n25 GND 0.00fF
C1971 a_9206_9752.t3 GND 0.02fF $ **FLOATING
C1972 a_9206_9752.n26 GND 0.07fF
C1973 a_9206_9752.n27 GND 0.02fF
C1974 a_9206_9752.n28 GND 0.05fF
C1975 a_9206_9752.n30 GND 0.01fF
C1976 a_9206_9752.n31 GND 0.00fF
C1977 a_9206_9752.n32 GND 0.01fF
C1978 a_9206_9752.n33 GND 0.00fF
C1979 a_9206_9752.n34 GND 0.00fF
C1980 a_9206_9752.n35 GND 0.00fF
C1981 a_9206_9752.n36 GND 0.00fF
C1982 a_9206_9752.n38 GND 0.08fF
C1983 a_9206_9752.t1 GND 4.25fF $ **FLOATING
C1984 a_9206_9752.n39 GND 0.62fF
C1985 a_9206_9752.t0 GND 0.26fF $ **FLOATING
C1986 a_8916_9676.n0 GND 0.01fF
C1987 a_8916_9676.n1 GND 0.01fF
C1988 a_8916_9676.n2 GND 0.00fF
C1989 a_8916_9676.n3 GND 0.00fF
C1990 a_8916_9676.n4 GND 0.00fF
C1991 a_8916_9676.n5 GND 0.00fF
C1992 a_8916_9676.n6 GND 0.00fF
C1993 a_8916_9676.n7 GND 0.00fF
C1994 a_8916_9676.n8 GND 0.00fF
C1995 a_8916_9676.n9 GND 0.00fF
C1996 a_8916_9676.t3 GND 0.02fF $ **FLOATING
C1997 a_8916_9676.t2 GND 0.02fF $ **FLOATING
C1998 a_8916_9676.n10 GND 0.05fF
C1999 a_8916_9676.n11 GND 0.00fF
C2000 a_8916_9676.n12 GND 0.00fF
C2001 a_8916_9676.n13 GND 0.02fF
C2002 a_8916_9676.n14 GND 0.05fF
C2003 a_8916_9676.n15 GND 0.13fF
C2004 a_8916_9676.n16 GND 0.01fF
C2005 a_8916_9676.n17 GND 0.12fF
C2006 a_8916_9676.t0 GND 3.94fF $ **FLOATING
C2007 a_8916_9676.n18 GND 0.53fF
C2008 a_8916_9676.t1 GND 0.24fF $ **FLOATING
C2009 a_16706_6092.n0 GND 0.00fF
C2010 a_16706_6092.n1 GND 0.00fF
C2011 a_16706_6092.n2 GND 0.01fF
C2012 a_16706_6092.n3 GND 0.01fF
C2013 a_16706_6092.n4 GND 0.00fF
C2014 a_16706_6092.n5 GND 0.01fF
C2015 a_16706_6092.n6 GND 0.00fF
C2016 a_16706_6092.n7 GND 0.00fF
C2017 a_16706_6092.n8 GND 0.00fF
C2018 a_16706_6092.n9 GND 0.00fF
C2019 a_16706_6092.n10 GND 0.09fF
C2020 a_16706_6092.n11 GND 0.00fF
C2021 a_16706_6092.n12 GND 0.01fF
C2022 a_16706_6092.n13 GND 0.01fF
C2023 a_16706_6092.n14 GND 0.01fF
C2024 a_16706_6092.n15 GND 0.00fF
C2025 a_16706_6092.n16 GND 0.00fF
C2026 a_16706_6092.n17 GND 0.00fF
C2027 a_16706_6092.t1 GND 0.02fF $ **FLOATING
C2028 a_16706_6092.n18 GND 0.07fF
C2029 a_16706_6092.n19 GND 0.02fF
C2030 a_16706_6092.n20 GND 0.05fF
C2031 a_16706_6092.n22 GND 0.04fF
C2032 a_16706_6092.n23 GND 0.04fF
C2033 a_16706_6092.n24 GND 0.00fF
C2034 a_16706_6092.n25 GND 0.00fF
C2035 a_16706_6092.t2 GND 0.02fF $ **FLOATING
C2036 a_16706_6092.n26 GND 0.07fF
C2037 a_16706_6092.n27 GND 0.02fF
C2038 a_16706_6092.n28 GND 0.05fF
C2039 a_16706_6092.n30 GND 0.01fF
C2040 a_16706_6092.n31 GND 0.00fF
C2041 a_16706_6092.n32 GND 0.01fF
C2042 a_16706_6092.n33 GND 0.00fF
C2043 a_16706_6092.n34 GND 0.00fF
C2044 a_16706_6092.n35 GND 0.00fF
C2045 a_16706_6092.n36 GND 0.00fF
C2046 a_16706_6092.n38 GND 0.08fF
C2047 a_16706_6092.t3 GND 4.25fF $ **FLOATING
C2048 a_16706_6092.n39 GND 0.62fF
C2049 a_16706_6092.t0 GND 0.26fF $ **FLOATING
C2050 a_16416_6016.n0 GND 0.01fF
C2051 a_16416_6016.n1 GND 0.01fF
C2052 a_16416_6016.n2 GND 0.00fF
C2053 a_16416_6016.n3 GND 0.00fF
C2054 a_16416_6016.n4 GND 0.00fF
C2055 a_16416_6016.n5 GND 0.00fF
C2056 a_16416_6016.n6 GND 0.00fF
C2057 a_16416_6016.n7 GND 0.00fF
C2058 a_16416_6016.n8 GND 0.00fF
C2059 a_16416_6016.n9 GND 0.00fF
C2060 a_16416_6016.t3 GND 0.02fF $ **FLOATING
C2061 a_16416_6016.t2 GND 0.02fF $ **FLOATING
C2062 a_16416_6016.n10 GND 0.05fF
C2063 a_16416_6016.n11 GND 0.00fF
C2064 a_16416_6016.n12 GND 0.00fF
C2065 a_16416_6016.n13 GND 0.02fF
C2066 a_16416_6016.n14 GND 0.05fF
C2067 a_16416_6016.n15 GND 0.13fF
C2068 a_16416_6016.n16 GND 0.01fF
C2069 a_16416_6016.n17 GND 0.12fF
C2070 a_16416_6016.t1 GND 3.94fF $ **FLOATING
C2071 a_16416_6016.n18 GND 0.53fF
C2072 a_16416_6016.t0 GND 0.24fF $ **FLOATING
C2073 VDD.n0 GND 0.01fF
C2074 VDD.n1 GND 0.00fF
C2075 VDD.t9 GND 0.20fF $ **FLOATING
C2076 VDD.n2 GND 0.04fF
C2077 VDD.n3 GND 0.00fF
C2078 VDD.t8 GND 0.45fF $ **FLOATING
C2079 VDD.n5 GND 0.16fF
C2080 VDD.n6 GND 0.01fF
C2081 VDD.n7 GND 0.01fF
C2082 VDD.n8 GND 0.00fF
C2083 VDD.n9 GND 0.01fF
C2084 VDD.n10 GND 0.03fF
C2085 VDD.n11 GND 0.01fF
C2086 VDD.n12 GND 0.01fF
C2087 VDD.n13 GND 0.00fF
C2088 VDD.n14 GND 0.01fF
C2089 VDD.n15 GND 0.01fF
C2090 VDD.n16 GND 0.12fF
C2091 VDD.n17 GND 0.01fF
C2092 VDD.n18 GND 1.13fF
C2093 VDD.n19 GND 0.01fF
C2094 VDD.n20 GND 0.00fF
C2095 VDD.t11 GND 0.20fF $ **FLOATING
C2096 VDD.n21 GND 0.04fF
C2097 VDD.n22 GND 0.00fF
C2098 VDD.t10 GND 0.45fF $ **FLOATING
C2099 VDD.n24 GND 0.16fF
C2100 VDD.n25 GND 0.01fF
C2101 VDD.n26 GND 0.01fF
C2102 VDD.n27 GND 0.00fF
C2103 VDD.n28 GND 0.01fF
C2104 VDD.n29 GND 0.03fF
C2105 VDD.n30 GND 0.01fF
C2106 VDD.n31 GND 0.01fF
C2107 VDD.n32 GND 0.00fF
C2108 VDD.n33 GND 0.01fF
C2109 VDD.n34 GND 0.01fF
C2110 VDD.n35 GND 0.12fF
C2111 VDD.n36 GND 0.01fF
C2112 VDD.n37 GND 0.14fF
C2113 VDD.n38 GND 1.64fF
C2114 VDD.n39 GND 0.01fF
C2115 VDD.n40 GND 0.00fF
C2116 VDD.t7 GND 0.20fF $ **FLOATING
C2117 VDD.n41 GND 0.04fF
C2118 VDD.n42 GND 0.00fF
C2119 VDD.t6 GND 0.45fF $ **FLOATING
C2120 VDD.n44 GND 0.16fF
C2121 VDD.n45 GND 0.01fF
C2122 VDD.n46 GND 0.01fF
C2123 VDD.n47 GND 0.00fF
C2124 VDD.n48 GND 0.01fF
C2125 VDD.n49 GND 0.03fF
C2126 VDD.n50 GND 0.01fF
C2127 VDD.n51 GND 0.01fF
C2128 VDD.n52 GND 0.00fF
C2129 VDD.n53 GND 0.01fF
C2130 VDD.n54 GND 0.01fF
C2131 VDD.n55 GND 0.12fF
C2132 VDD.n56 GND 0.01fF
C2133 VDD.n57 GND 0.14fF
C2134 VDD.n58 GND 0.81fF
C2135 VDD.n59 GND 0.01fF
C2136 VDD.n60 GND 0.00fF
C2137 VDD.t3 GND 0.20fF $ **FLOATING
C2138 VDD.n61 GND 0.04fF
C2139 VDD.n62 GND 0.00fF
C2140 VDD.t2 GND 0.45fF $ **FLOATING
C2141 VDD.n64 GND 0.16fF
C2142 VDD.n65 GND 0.01fF
C2143 VDD.n66 GND 0.01fF
C2144 VDD.n67 GND 0.00fF
C2145 VDD.n68 GND 0.01fF
C2146 VDD.n69 GND 0.03fF
C2147 VDD.n70 GND 0.01fF
C2148 VDD.n71 GND 0.01fF
C2149 VDD.n72 GND 0.00fF
C2150 VDD.n73 GND 0.01fF
C2151 VDD.n74 GND 0.01fF
C2152 VDD.n75 GND 0.12fF
C2153 VDD.n76 GND 0.01fF
C2154 VDD.n77 GND 0.14fF
C2155 VDD.n78 GND 0.57fF
C2156 VDD.n79 GND 0.01fF
C2157 VDD.n80 GND 0.00fF
C2158 VDD.t1 GND 0.20fF $ **FLOATING
C2159 VDD.n81 GND 0.04fF
C2160 VDD.n82 GND 0.00fF
C2161 VDD.t0 GND 0.45fF $ **FLOATING
C2162 VDD.n84 GND 0.16fF
C2163 VDD.n85 GND 0.01fF
C2164 VDD.n86 GND 0.01fF
C2165 VDD.n87 GND 0.00fF
C2166 VDD.n88 GND 0.01fF
C2167 VDD.n89 GND 0.03fF
C2168 VDD.n90 GND 0.01fF
C2169 VDD.n91 GND 0.01fF
C2170 VDD.n92 GND 0.00fF
C2171 VDD.n93 GND 0.01fF
C2172 VDD.n94 GND 0.01fF
C2173 VDD.n95 GND 0.12fF
C2174 VDD.n96 GND 0.01fF
C2175 VDD.n97 GND 0.14fF
C2176 VDD.n98 GND 0.57fF
C2177 VDD.n99 GND 0.01fF
C2178 VDD.n100 GND 0.00fF
C2179 VDD.t5 GND 0.20fF $ **FLOATING
C2180 VDD.n101 GND 0.04fF
C2181 VDD.n102 GND 0.00fF
C2182 VDD.t4 GND 0.45fF $ **FLOATING
C2183 VDD.n104 GND 0.16fF
C2184 VDD.n105 GND 0.01fF
C2185 VDD.n106 GND 0.01fF
C2186 VDD.n107 GND 0.00fF
C2187 VDD.n108 GND 0.01fF
C2188 VDD.n109 GND 0.03fF
C2189 VDD.n110 GND 0.01fF
C2190 VDD.n111 GND 0.01fF
C2191 VDD.n112 GND 0.00fF
C2192 VDD.n113 GND 0.01fF
C2193 VDD.n114 GND 0.01fF
C2194 VDD.n115 GND 0.12fF
C2195 VDD.n116 GND 0.01fF
C2196 VDD.n117 GND 0.14fF
C2197 VDD.n118 GND 0.45fF
C2198 a_1416_16996.n0 GND 0.01fF
C2199 a_1416_16996.n1 GND 0.01fF
C2200 a_1416_16996.n2 GND 0.00fF
C2201 a_1416_16996.n3 GND 0.01fF
C2202 a_1416_16996.n4 GND 0.01fF
C2203 a_1416_16996.n5 GND 0.01fF
C2204 a_1416_16996.n6 GND 0.00fF
C2205 a_1416_16996.n7 GND 0.00fF
C2206 a_1416_16996.n8 GND 0.00fF
C2207 a_1416_16996.n9 GND 0.00fF
C2208 a_1416_16996.t2 GND 0.03fF $ **FLOATING
C2209 a_1416_16996.t1 GND 0.03fF $ **FLOATING
C2210 a_1416_16996.n10 GND 0.07fF
C2211 a_1416_16996.n11 GND 0.00fF
C2212 a_1416_16996.n12 GND 0.01fF
C2213 a_1416_16996.n13 GND 0.02fF
C2214 a_1416_16996.n14 GND 0.06fF
C2215 a_1416_16996.n15 GND 0.18fF
C2216 a_1416_16996.n16 GND 0.02fF
C2217 a_1416_16996.n17 GND 0.17fF
C2218 a_1416_16996.t0 GND 5.56fF $ **FLOATING
C2219 a_1416_16996.n18 GND 0.75fF
C2220 a_1416_16996.t3 GND 0.34fF $ **FLOATING
C2221 a_12956_7922.n0 GND 0.00fF
C2222 a_12956_7922.n1 GND 0.00fF
C2223 a_12956_7922.n2 GND 0.01fF
C2224 a_12956_7922.n3 GND 0.01fF
C2225 a_12956_7922.n4 GND 0.00fF
C2226 a_12956_7922.n5 GND 0.01fF
C2227 a_12956_7922.n6 GND 0.00fF
C2228 a_12956_7922.n7 GND 0.00fF
C2229 a_12956_7922.n8 GND 0.00fF
C2230 a_12956_7922.n9 GND 0.00fF
C2231 a_12956_7922.n10 GND 0.09fF
C2232 a_12956_7922.n11 GND 0.00fF
C2233 a_12956_7922.n12 GND 0.01fF
C2234 a_12956_7922.n13 GND 0.01fF
C2235 a_12956_7922.n14 GND 0.01fF
C2236 a_12956_7922.n15 GND 0.00fF
C2237 a_12956_7922.n16 GND 0.00fF
C2238 a_12956_7922.n17 GND 0.00fF
C2239 a_12956_7922.t3 GND 0.02fF $ **FLOATING
C2240 a_12956_7922.n18 GND 0.07fF
C2241 a_12956_7922.n19 GND 0.02fF
C2242 a_12956_7922.n20 GND 0.05fF
C2243 a_12956_7922.n22 GND 0.04fF
C2244 a_12956_7922.n23 GND 0.04fF
C2245 a_12956_7922.n24 GND 0.00fF
C2246 a_12956_7922.n25 GND 0.00fF
C2247 a_12956_7922.t2 GND 0.02fF $ **FLOATING
C2248 a_12956_7922.n26 GND 0.07fF
C2249 a_12956_7922.n27 GND 0.02fF
C2250 a_12956_7922.n28 GND 0.05fF
C2251 a_12956_7922.n30 GND 0.01fF
C2252 a_12956_7922.n31 GND 0.00fF
C2253 a_12956_7922.n32 GND 0.01fF
C2254 a_12956_7922.n33 GND 0.00fF
C2255 a_12956_7922.n34 GND 0.00fF
C2256 a_12956_7922.n35 GND 0.00fF
C2257 a_12956_7922.n36 GND 0.00fF
C2258 a_12956_7922.n38 GND 0.08fF
C2259 a_12956_7922.t1 GND 4.25fF $ **FLOATING
C2260 a_12956_7922.n39 GND 0.62fF
C2261 a_12956_7922.t0 GND 0.26fF $ **FLOATING
C2262 a_1416_526.n0 GND 0.01fF
C2263 a_1416_526.n1 GND 0.01fF
C2264 a_1416_526.n2 GND 0.00fF
C2265 a_1416_526.n3 GND 0.00fF
C2266 a_1416_526.n4 GND 0.00fF
C2267 a_1416_526.n5 GND 0.00fF
C2268 a_1416_526.n6 GND 0.00fF
C2269 a_1416_526.n7 GND 0.00fF
C2270 a_1416_526.n8 GND 0.00fF
C2271 a_1416_526.n9 GND 0.00fF
C2272 a_1416_526.t2 GND 0.02fF $ **FLOATING
C2273 a_1416_526.t3 GND 0.02fF $ **FLOATING
C2274 a_1416_526.n10 GND 0.05fF
C2275 a_1416_526.n11 GND 0.00fF
C2276 a_1416_526.n12 GND 0.00fF
C2277 a_1416_526.n13 GND 0.02fF
C2278 a_1416_526.n14 GND 0.05fF
C2279 a_1416_526.n15 GND 0.13fF
C2280 a_1416_526.n16 GND 0.01fF
C2281 a_1416_526.n17 GND 0.12fF
C2282 a_1416_526.t1 GND 3.94fF $ **FLOATING
C2283 a_1416_526.n18 GND 0.53fF
C2284 a_1416_526.t0 GND 0.24fF $ **FLOATING
C2285 a_5166_6016.n0 GND 0.01fF
C2286 a_5166_6016.n1 GND 0.01fF
C2287 a_5166_6016.n2 GND 0.00fF
C2288 a_5166_6016.n3 GND 0.00fF
C2289 a_5166_6016.n4 GND 0.00fF
C2290 a_5166_6016.n5 GND 0.00fF
C2291 a_5166_6016.n6 GND 0.00fF
C2292 a_5166_6016.n7 GND 0.00fF
C2293 a_5166_6016.n8 GND 0.00fF
C2294 a_5166_6016.n9 GND 0.00fF
C2295 a_5166_6016.t2 GND 0.02fF $ **FLOATING
C2296 a_5166_6016.t3 GND 0.02fF $ **FLOATING
C2297 a_5166_6016.n10 GND 0.05fF
C2298 a_5166_6016.n11 GND 0.00fF
C2299 a_5166_6016.n12 GND 0.00fF
C2300 a_5166_6016.n13 GND 0.02fF
C2301 a_5166_6016.n14 GND 0.05fF
C2302 a_5166_6016.n15 GND 0.13fF
C2303 a_5166_6016.n16 GND 0.01fF
C2304 a_5166_6016.n17 GND 0.12fF
C2305 a_5166_6016.t0 GND 3.94fF $ **FLOATING
C2306 a_5166_6016.n18 GND 0.53fF
C2307 a_5166_6016.t1 GND 0.24fF $ **FLOATING
C2308 a_1706_602.n0 GND 0.00fF
C2309 a_1706_602.n1 GND 0.00fF
C2310 a_1706_602.n2 GND 0.01fF
C2311 a_1706_602.n3 GND 0.01fF
C2312 a_1706_602.n4 GND 0.00fF
C2313 a_1706_602.n5 GND 0.01fF
C2314 a_1706_602.n6 GND 0.00fF
C2315 a_1706_602.n7 GND 0.00fF
C2316 a_1706_602.n8 GND 0.00fF
C2317 a_1706_602.n9 GND 0.00fF
C2318 a_1706_602.n10 GND 0.09fF
C2319 a_1706_602.n11 GND 0.00fF
C2320 a_1706_602.n12 GND 0.01fF
C2321 a_1706_602.n13 GND 0.01fF
C2322 a_1706_602.n14 GND 0.01fF
C2323 a_1706_602.n15 GND 0.00fF
C2324 a_1706_602.n16 GND 0.00fF
C2325 a_1706_602.n17 GND 0.00fF
C2326 a_1706_602.t2 GND 0.02fF $ **FLOATING
C2327 a_1706_602.n18 GND 0.07fF
C2328 a_1706_602.n19 GND 0.02fF
C2329 a_1706_602.n20 GND 0.05fF
C2330 a_1706_602.n22 GND 0.04fF
C2331 a_1706_602.n23 GND 0.04fF
C2332 a_1706_602.n24 GND 0.00fF
C2333 a_1706_602.n25 GND 0.00fF
C2334 a_1706_602.t1 GND 0.02fF $ **FLOATING
C2335 a_1706_602.n26 GND 0.07fF
C2336 a_1706_602.n27 GND 0.02fF
C2337 a_1706_602.n28 GND 0.05fF
C2338 a_1706_602.n30 GND 0.01fF
C2339 a_1706_602.n31 GND 0.00fF
C2340 a_1706_602.n32 GND 0.01fF
C2341 a_1706_602.n33 GND 0.00fF
C2342 a_1706_602.n34 GND 0.00fF
C2343 a_1706_602.n35 GND 0.00fF
C2344 a_1706_602.n36 GND 0.00fF
C2345 a_1706_602.n38 GND 0.08fF
C2346 a_1706_602.t3 GND 4.25fF $ **FLOATING
C2347 a_1706_602.n39 GND 0.62fF
C2348 a_1706_602.t0 GND 0.26fF $ **FLOATING
C2349 a_20456_602.n0 GND 0.00fF
C2350 a_20456_602.n1 GND 0.00fF
C2351 a_20456_602.n2 GND 0.01fF
C2352 a_20456_602.n3 GND 0.01fF
C2353 a_20456_602.n4 GND 0.00fF
C2354 a_20456_602.n5 GND 0.01fF
C2355 a_20456_602.n6 GND 0.00fF
C2356 a_20456_602.n7 GND 0.00fF
C2357 a_20456_602.n8 GND 0.00fF
C2358 a_20456_602.n9 GND 0.00fF
C2359 a_20456_602.n10 GND 0.09fF
C2360 a_20456_602.n11 GND 0.00fF
C2361 a_20456_602.n12 GND 0.01fF
C2362 a_20456_602.n13 GND 0.01fF
C2363 a_20456_602.n14 GND 0.01fF
C2364 a_20456_602.n15 GND 0.00fF
C2365 a_20456_602.n16 GND 0.00fF
C2366 a_20456_602.n17 GND 0.00fF
C2367 a_20456_602.t2 GND 0.02fF $ **FLOATING
C2368 a_20456_602.n18 GND 0.07fF
C2369 a_20456_602.n19 GND 0.02fF
C2370 a_20456_602.n20 GND 0.05fF
C2371 a_20456_602.n22 GND 0.04fF
C2372 a_20456_602.n23 GND 0.04fF
C2373 a_20456_602.n24 GND 0.00fF
C2374 a_20456_602.n25 GND 0.00fF
C2375 a_20456_602.t1 GND 0.02fF $ **FLOATING
C2376 a_20456_602.n26 GND 0.07fF
C2377 a_20456_602.n27 GND 0.02fF
C2378 a_20456_602.n28 GND 0.05fF
C2379 a_20456_602.n30 GND 0.01fF
C2380 a_20456_602.n31 GND 0.00fF
C2381 a_20456_602.n32 GND 0.01fF
C2382 a_20456_602.n33 GND 0.00fF
C2383 a_20456_602.n34 GND 0.00fF
C2384 a_20456_602.n35 GND 0.00fF
C2385 a_20456_602.n36 GND 0.00fF
C2386 a_20456_602.n38 GND 0.08fF
C2387 a_20456_602.t3 GND 4.25fF $ **FLOATING
C2388 a_20456_602.n39 GND 0.62fF
C2389 a_20456_602.t0 GND 0.26fF $ **FLOATING
C2390 a_27666_6016.n0 GND 0.01fF
C2391 a_27666_6016.n1 GND 0.01fF
C2392 a_27666_6016.n2 GND 0.00fF
C2393 a_27666_6016.n3 GND 0.00fF
C2394 a_27666_6016.n4 GND 0.00fF
C2395 a_27666_6016.n5 GND 0.00fF
C2396 a_27666_6016.n6 GND 0.00fF
C2397 a_27666_6016.n7 GND 0.00fF
C2398 a_27666_6016.n8 GND 0.00fF
C2399 a_27666_6016.n9 GND 0.00fF
C2400 a_27666_6016.t2 GND 0.02fF $ **FLOATING
C2401 a_27666_6016.t3 GND 0.02fF $ **FLOATING
C2402 a_27666_6016.n10 GND 0.05fF
C2403 a_27666_6016.n11 GND 0.00fF
C2404 a_27666_6016.n12 GND 0.00fF
C2405 a_27666_6016.n13 GND 0.02fF
C2406 a_27666_6016.n14 GND 0.05fF
C2407 a_27666_6016.n15 GND 0.13fF
C2408 a_27666_6016.n16 GND 0.01fF
C2409 a_27666_6016.n17 GND 0.12fF
C2410 a_27666_6016.t1 GND 3.94fF $ **FLOATING
C2411 a_27666_6016.n18 GND 0.53fF
C2412 a_27666_6016.t0 GND 0.24fF $ **FLOATING
C2413 a_8916_2356.n0 GND 0.01fF
C2414 a_8916_2356.n1 GND 0.01fF
C2415 a_8916_2356.n2 GND 0.00fF
C2416 a_8916_2356.n3 GND 0.00fF
C2417 a_8916_2356.n4 GND 0.00fF
C2418 a_8916_2356.n5 GND 0.00fF
C2419 a_8916_2356.n6 GND 0.00fF
C2420 a_8916_2356.n7 GND 0.00fF
C2421 a_8916_2356.n8 GND 0.00fF
C2422 a_8916_2356.n9 GND 0.00fF
C2423 a_8916_2356.t2 GND 0.02fF $ **FLOATING
C2424 a_8916_2356.t3 GND 0.02fF $ **FLOATING
C2425 a_8916_2356.n10 GND 0.05fF
C2426 a_8916_2356.n11 GND 0.00fF
C2427 a_8916_2356.n12 GND 0.00fF
C2428 a_8916_2356.n13 GND 0.02fF
C2429 a_8916_2356.n14 GND 0.05fF
C2430 a_8916_2356.n15 GND 0.13fF
C2431 a_8916_2356.n16 GND 0.01fF
C2432 a_8916_2356.n17 GND 0.12fF
C2433 a_8916_2356.t0 GND 3.94fF $ **FLOATING
C2434 a_8916_2356.n18 GND 0.53fF
C2435 a_8916_2356.t1 GND 0.24fF $ **FLOATING
C2436 a_9206_2432.n0 GND 0.00fF
C2437 a_9206_2432.n1 GND 0.00fF
C2438 a_9206_2432.n2 GND 0.01fF
C2439 a_9206_2432.n3 GND 0.01fF
C2440 a_9206_2432.n4 GND 0.00fF
C2441 a_9206_2432.n5 GND 0.01fF
C2442 a_9206_2432.n6 GND 0.00fF
C2443 a_9206_2432.n7 GND 0.00fF
C2444 a_9206_2432.n8 GND 0.00fF
C2445 a_9206_2432.n9 GND 0.00fF
C2446 a_9206_2432.n10 GND 0.09fF
C2447 a_9206_2432.n11 GND 0.00fF
C2448 a_9206_2432.n12 GND 0.01fF
C2449 a_9206_2432.n13 GND 0.01fF
C2450 a_9206_2432.n14 GND 0.01fF
C2451 a_9206_2432.n15 GND 0.00fF
C2452 a_9206_2432.n16 GND 0.00fF
C2453 a_9206_2432.n17 GND 0.00fF
C2454 a_9206_2432.t2 GND 0.02fF $ **FLOATING
C2455 a_9206_2432.n18 GND 0.07fF
C2456 a_9206_2432.n19 GND 0.02fF
C2457 a_9206_2432.n20 GND 0.05fF
C2458 a_9206_2432.n22 GND 0.04fF
C2459 a_9206_2432.n23 GND 0.04fF
C2460 a_9206_2432.n24 GND 0.00fF
C2461 a_9206_2432.n25 GND 0.00fF
C2462 a_9206_2432.t1 GND 0.02fF $ **FLOATING
C2463 a_9206_2432.n26 GND 0.07fF
C2464 a_9206_2432.n27 GND 0.02fF
C2465 a_9206_2432.n28 GND 0.05fF
C2466 a_9206_2432.n30 GND 0.01fF
C2467 a_9206_2432.n31 GND 0.00fF
C2468 a_9206_2432.n32 GND 0.01fF
C2469 a_9206_2432.n33 GND 0.00fF
C2470 a_9206_2432.n34 GND 0.00fF
C2471 a_9206_2432.n35 GND 0.00fF
C2472 a_9206_2432.n36 GND 0.00fF
C2473 a_9206_2432.n38 GND 0.08fF
C2474 a_9206_2432.t3 GND 4.25fF $ **FLOATING
C2475 a_9206_2432.n39 GND 0.62fF
C2476 a_9206_2432.t0 GND 0.26fF $ **FLOATING
C2477 a_5166_2356.n0 GND 0.01fF
C2478 a_5166_2356.n1 GND 0.01fF
C2479 a_5166_2356.n2 GND 0.00fF
C2480 a_5166_2356.n3 GND 0.00fF
C2481 a_5166_2356.n4 GND 0.00fF
C2482 a_5166_2356.n5 GND 0.00fF
C2483 a_5166_2356.n6 GND 0.00fF
C2484 a_5166_2356.n7 GND 0.00fF
C2485 a_5166_2356.n8 GND 0.00fF
C2486 a_5166_2356.n9 GND 0.00fF
C2487 a_5166_2356.t2 GND 0.02fF $ **FLOATING
C2488 a_5166_2356.t3 GND 0.02fF $ **FLOATING
C2489 a_5166_2356.n10 GND 0.05fF
C2490 a_5166_2356.n11 GND 0.00fF
C2491 a_5166_2356.n12 GND 0.00fF
C2492 a_5166_2356.n13 GND 0.02fF
C2493 a_5166_2356.n14 GND 0.05fF
C2494 a_5166_2356.n15 GND 0.13fF
C2495 a_5166_2356.n16 GND 0.01fF
C2496 a_5166_2356.n17 GND 0.12fF
C2497 a_5166_2356.t0 GND 3.94fF $ **FLOATING
C2498 a_5166_2356.n18 GND 0.53fF
C2499 a_5166_2356.t1 GND 0.24fF $ **FLOATING
C2500 a_5456_7922.n0 GND 0.00fF
C2501 a_5456_7922.n1 GND 0.00fF
C2502 a_5456_7922.n2 GND 0.01fF
C2503 a_5456_7922.n3 GND 0.01fF
C2504 a_5456_7922.n4 GND 0.00fF
C2505 a_5456_7922.n5 GND 0.01fF
C2506 a_5456_7922.n6 GND 0.00fF
C2507 a_5456_7922.n7 GND 0.00fF
C2508 a_5456_7922.n8 GND 0.00fF
C2509 a_5456_7922.n9 GND 0.00fF
C2510 a_5456_7922.n10 GND 0.09fF
C2511 a_5456_7922.n11 GND 0.00fF
C2512 a_5456_7922.n12 GND 0.01fF
C2513 a_5456_7922.n13 GND 0.01fF
C2514 a_5456_7922.n14 GND 0.01fF
C2515 a_5456_7922.n15 GND 0.00fF
C2516 a_5456_7922.n16 GND 0.00fF
C2517 a_5456_7922.n17 GND 0.00fF
C2518 a_5456_7922.t3 GND 0.02fF $ **FLOATING
C2519 a_5456_7922.n18 GND 0.07fF
C2520 a_5456_7922.n19 GND 0.02fF
C2521 a_5456_7922.n20 GND 0.05fF
C2522 a_5456_7922.n22 GND 0.04fF
C2523 a_5456_7922.n23 GND 0.04fF
C2524 a_5456_7922.n24 GND 0.00fF
C2525 a_5456_7922.n25 GND 0.00fF
C2526 a_5456_7922.t2 GND 0.02fF $ **FLOATING
C2527 a_5456_7922.n26 GND 0.07fF
C2528 a_5456_7922.n27 GND 0.02fF
C2529 a_5456_7922.n28 GND 0.05fF
C2530 a_5456_7922.n30 GND 0.01fF
C2531 a_5456_7922.n31 GND 0.00fF
C2532 a_5456_7922.n32 GND 0.01fF
C2533 a_5456_7922.n33 GND 0.00fF
C2534 a_5456_7922.n34 GND 0.00fF
C2535 a_5456_7922.n35 GND 0.00fF
C2536 a_5456_7922.n36 GND 0.00fF
C2537 a_5456_7922.n38 GND 0.08fF
C2538 a_5456_7922.t1 GND 4.25fF $ **FLOATING
C2539 a_5456_7922.n39 GND 0.62fF
C2540 a_5456_7922.t0 GND 0.26fF $ **FLOATING
C2541 a_16706_9752.n0 GND 0.00fF
C2542 a_16706_9752.n1 GND 0.00fF
C2543 a_16706_9752.n2 GND 0.01fF
C2544 a_16706_9752.n3 GND 0.01fF
C2545 a_16706_9752.n4 GND 0.00fF
C2546 a_16706_9752.n5 GND 0.01fF
C2547 a_16706_9752.n6 GND 0.00fF
C2548 a_16706_9752.n7 GND 0.00fF
C2549 a_16706_9752.n8 GND 0.00fF
C2550 a_16706_9752.n9 GND 0.00fF
C2551 a_16706_9752.n10 GND 0.09fF
C2552 a_16706_9752.n11 GND 0.00fF
C2553 a_16706_9752.n12 GND 0.01fF
C2554 a_16706_9752.n13 GND 0.01fF
C2555 a_16706_9752.n14 GND 0.01fF
C2556 a_16706_9752.n15 GND 0.00fF
C2557 a_16706_9752.n16 GND 0.00fF
C2558 a_16706_9752.n17 GND 0.00fF
C2559 a_16706_9752.t2 GND 0.02fF $ **FLOATING
C2560 a_16706_9752.n18 GND 0.07fF
C2561 a_16706_9752.n19 GND 0.02fF
C2562 a_16706_9752.n20 GND 0.05fF
C2563 a_16706_9752.n22 GND 0.04fF
C2564 a_16706_9752.n23 GND 0.04fF
C2565 a_16706_9752.n24 GND 0.00fF
C2566 a_16706_9752.n25 GND 0.00fF
C2567 a_16706_9752.t3 GND 0.02fF $ **FLOATING
C2568 a_16706_9752.n26 GND 0.07fF
C2569 a_16706_9752.n27 GND 0.02fF
C2570 a_16706_9752.n28 GND 0.05fF
C2571 a_16706_9752.n30 GND 0.01fF
C2572 a_16706_9752.n31 GND 0.00fF
C2573 a_16706_9752.n32 GND 0.01fF
C2574 a_16706_9752.n33 GND 0.00fF
C2575 a_16706_9752.n34 GND 0.00fF
C2576 a_16706_9752.n35 GND 0.00fF
C2577 a_16706_9752.n36 GND 0.00fF
C2578 a_16706_9752.n38 GND 0.08fF
C2579 a_16706_9752.t1 GND 4.25fF $ **FLOATING
C2580 a_16706_9752.n39 GND 0.62fF
C2581 a_16706_9752.t0 GND 0.26fF $ **FLOATING
C2582 a_16416_9676.n0 GND 0.01fF
C2583 a_16416_9676.n1 GND 0.01fF
C2584 a_16416_9676.n2 GND 0.00fF
C2585 a_16416_9676.n3 GND 0.00fF
C2586 a_16416_9676.n4 GND 0.00fF
C2587 a_16416_9676.n5 GND 0.00fF
C2588 a_16416_9676.n6 GND 0.00fF
C2589 a_16416_9676.n7 GND 0.00fF
C2590 a_16416_9676.n8 GND 0.00fF
C2591 a_16416_9676.n9 GND 0.00fF
C2592 a_16416_9676.t3 GND 0.02fF $ **FLOATING
C2593 a_16416_9676.t2 GND 0.02fF $ **FLOATING
C2594 a_16416_9676.n10 GND 0.05fF
C2595 a_16416_9676.n11 GND 0.00fF
C2596 a_16416_9676.n12 GND 0.00fF
C2597 a_16416_9676.n13 GND 0.02fF
C2598 a_16416_9676.n14 GND 0.05fF
C2599 a_16416_9676.n15 GND 0.13fF
C2600 a_16416_9676.n16 GND 0.01fF
C2601 a_16416_9676.n17 GND 0.12fF
C2602 a_16416_9676.t1 GND 3.94fF $ **FLOATING
C2603 a_16416_9676.n18 GND 0.53fF
C2604 a_16416_9676.t0 GND 0.24fF $ **FLOATING
C2605 a_27666_526.n0 GND 0.01fF
C2606 a_27666_526.n1 GND 0.01fF
C2607 a_27666_526.n2 GND 0.00fF
C2608 a_27666_526.n3 GND 0.00fF
C2609 a_27666_526.n4 GND 0.00fF
C2610 a_27666_526.n5 GND 0.00fF
C2611 a_27666_526.n6 GND 0.00fF
C2612 a_27666_526.n7 GND 0.00fF
C2613 a_27666_526.n8 GND 0.00fF
C2614 a_27666_526.n9 GND 0.00fF
C2615 a_27666_526.t2 GND 0.02fF $ **FLOATING
C2616 a_27666_526.t3 GND 0.02fF $ **FLOATING
C2617 a_27666_526.n10 GND 0.05fF
C2618 a_27666_526.n11 GND 0.00fF
C2619 a_27666_526.n12 GND 0.00fF
C2620 a_27666_526.n13 GND 0.02fF
C2621 a_27666_526.n14 GND 0.05fF
C2622 a_27666_526.n15 GND 0.13fF
C2623 a_27666_526.n16 GND 0.01fF
C2624 a_27666_526.n17 GND 0.12fF
C2625 a_27666_526.t1 GND 3.94fF $ **FLOATING
C2626 a_27666_526.n18 GND 0.53fF
C2627 a_27666_526.t0 GND 0.24fF $ **FLOATING
C2628 a_8916_526.n0 GND 0.01fF
C2629 a_8916_526.n1 GND 0.01fF
C2630 a_8916_526.n2 GND 0.00fF
C2631 a_8916_526.n3 GND 0.00fF
C2632 a_8916_526.n4 GND 0.00fF
C2633 a_8916_526.n5 GND 0.00fF
C2634 a_8916_526.n6 GND 0.00fF
C2635 a_8916_526.n7 GND 0.00fF
C2636 a_8916_526.n8 GND 0.00fF
C2637 a_8916_526.n9 GND 0.00fF
C2638 a_8916_526.t2 GND 0.02fF $ **FLOATING
C2639 a_8916_526.t3 GND 0.02fF $ **FLOATING
C2640 a_8916_526.n10 GND 0.05fF
C2641 a_8916_526.n11 GND 0.00fF
C2642 a_8916_526.n12 GND 0.00fF
C2643 a_8916_526.n13 GND 0.02fF
C2644 a_8916_526.n14 GND 0.05fF
C2645 a_8916_526.n15 GND 0.13fF
C2646 a_8916_526.n16 GND 0.01fF
C2647 a_8916_526.n17 GND 0.12fF
C2648 a_8916_526.t1 GND 3.94fF $ **FLOATING
C2649 a_8916_526.n18 GND 0.53fF
C2650 a_8916_526.t0 GND 0.24fF $ **FLOATING
C2651 a_9206_602.n0 GND 0.00fF
C2652 a_9206_602.n1 GND 0.00fF
C2653 a_9206_602.n2 GND 0.01fF
C2654 a_9206_602.n3 GND 0.01fF
C2655 a_9206_602.n4 GND 0.00fF
C2656 a_9206_602.n5 GND 0.01fF
C2657 a_9206_602.n6 GND 0.00fF
C2658 a_9206_602.n7 GND 0.00fF
C2659 a_9206_602.n8 GND 0.00fF
C2660 a_9206_602.n9 GND 0.00fF
C2661 a_9206_602.n10 GND 0.09fF
C2662 a_9206_602.n11 GND 0.00fF
C2663 a_9206_602.n12 GND 0.01fF
C2664 a_9206_602.n13 GND 0.01fF
C2665 a_9206_602.n14 GND 0.01fF
C2666 a_9206_602.n15 GND 0.00fF
C2667 a_9206_602.n16 GND 0.00fF
C2668 a_9206_602.n17 GND 0.00fF
C2669 a_9206_602.t2 GND 0.02fF $ **FLOATING
C2670 a_9206_602.n18 GND 0.07fF
C2671 a_9206_602.n19 GND 0.02fF
C2672 a_9206_602.n20 GND 0.05fF
C2673 a_9206_602.n22 GND 0.04fF
C2674 a_9206_602.n23 GND 0.04fF
C2675 a_9206_602.n24 GND 0.00fF
C2676 a_9206_602.n25 GND 0.00fF
C2677 a_9206_602.t1 GND 0.02fF $ **FLOATING
C2678 a_9206_602.n26 GND 0.07fF
C2679 a_9206_602.n27 GND 0.02fF
C2680 a_9206_602.n28 GND 0.05fF
C2681 a_9206_602.n30 GND 0.01fF
C2682 a_9206_602.n31 GND 0.00fF
C2683 a_9206_602.n32 GND 0.01fF
C2684 a_9206_602.n33 GND 0.00fF
C2685 a_9206_602.n34 GND 0.00fF
C2686 a_9206_602.n35 GND 0.00fF
C2687 a_9206_602.n36 GND 0.00fF
C2688 a_9206_602.n38 GND 0.08fF
C2689 a_9206_602.t3 GND 4.25fF $ **FLOATING
C2690 a_9206_602.n39 GND 0.62fF
C2691 a_9206_602.t0 GND 0.26fF $ **FLOATING
C2692 a_23916_2356.n0 GND 0.01fF
C2693 a_23916_2356.n1 GND 0.01fF
C2694 a_23916_2356.n2 GND 0.00fF
C2695 a_23916_2356.n3 GND 0.00fF
C2696 a_23916_2356.n4 GND 0.00fF
C2697 a_23916_2356.n5 GND 0.00fF
C2698 a_23916_2356.n6 GND 0.00fF
C2699 a_23916_2356.n7 GND 0.00fF
C2700 a_23916_2356.n8 GND 0.00fF
C2701 a_23916_2356.n9 GND 0.00fF
C2702 a_23916_2356.t3 GND 0.02fF $ **FLOATING
C2703 a_23916_2356.t2 GND 0.02fF $ **FLOATING
C2704 a_23916_2356.n10 GND 0.05fF
C2705 a_23916_2356.n11 GND 0.00fF
C2706 a_23916_2356.n12 GND 0.00fF
C2707 a_23916_2356.n13 GND 0.02fF
C2708 a_23916_2356.n14 GND 0.05fF
C2709 a_23916_2356.n15 GND 0.13fF
C2710 a_23916_2356.n16 GND 0.01fF
C2711 a_23916_2356.n17 GND 0.12fF
C2712 a_23916_2356.t1 GND 3.94fF $ **FLOATING
C2713 a_23916_2356.n18 GND 0.53fF
C2714 a_23916_2356.t0 GND 0.24fF $ **FLOATING
C2715 a_9206_13412.n0 GND 0.00fF
C2716 a_9206_13412.n1 GND 0.00fF
C2717 a_9206_13412.n2 GND 0.01fF
C2718 a_9206_13412.n3 GND 0.01fF
C2719 a_9206_13412.n4 GND 0.00fF
C2720 a_9206_13412.n5 GND 0.01fF
C2721 a_9206_13412.n6 GND 0.00fF
C2722 a_9206_13412.n7 GND 0.00fF
C2723 a_9206_13412.n8 GND 0.00fF
C2724 a_9206_13412.n9 GND 0.00fF
C2725 a_9206_13412.n10 GND 0.09fF
C2726 a_9206_13412.n11 GND 0.00fF
C2727 a_9206_13412.n12 GND 0.01fF
C2728 a_9206_13412.n13 GND 0.01fF
C2729 a_9206_13412.n14 GND 0.01fF
C2730 a_9206_13412.n15 GND 0.00fF
C2731 a_9206_13412.n16 GND 0.00fF
C2732 a_9206_13412.n17 GND 0.00fF
C2733 a_9206_13412.t1 GND 0.02fF $ **FLOATING
C2734 a_9206_13412.n18 GND 0.07fF
C2735 a_9206_13412.n19 GND 0.02fF
C2736 a_9206_13412.n20 GND 0.05fF
C2737 a_9206_13412.n22 GND 0.04fF
C2738 a_9206_13412.n23 GND 0.04fF
C2739 a_9206_13412.n24 GND 0.00fF
C2740 a_9206_13412.n25 GND 0.00fF
C2741 a_9206_13412.t0 GND 0.02fF $ **FLOATING
C2742 a_9206_13412.n26 GND 0.07fF
C2743 a_9206_13412.n27 GND 0.02fF
C2744 a_9206_13412.n28 GND 0.05fF
C2745 a_9206_13412.n30 GND 0.01fF
C2746 a_9206_13412.n31 GND 0.00fF
C2747 a_9206_13412.n32 GND 0.01fF
C2748 a_9206_13412.n33 GND 0.00fF
C2749 a_9206_13412.n34 GND 0.00fF
C2750 a_9206_13412.n35 GND 0.00fF
C2751 a_9206_13412.n36 GND 0.00fF
C2752 a_9206_13412.n38 GND 0.08fF
C2753 a_9206_13412.t3 GND 4.25fF $ **FLOATING
C2754 a_9206_13412.n39 GND 0.62fF
C2755 a_9206_13412.t2 GND 0.26fF $ **FLOATING
C2756 a_12956_13412.n0 GND 0.00fF
C2757 a_12956_13412.n1 GND 0.00fF
C2758 a_12956_13412.n2 GND 0.01fF
C2759 a_12956_13412.n3 GND 0.01fF
C2760 a_12956_13412.n4 GND 0.00fF
C2761 a_12956_13412.n5 GND 0.01fF
C2762 a_12956_13412.n6 GND 0.00fF
C2763 a_12956_13412.n7 GND 0.00fF
C2764 a_12956_13412.n8 GND 0.00fF
C2765 a_12956_13412.n9 GND 0.00fF
C2766 a_12956_13412.n10 GND 0.09fF
C2767 a_12956_13412.n11 GND 0.00fF
C2768 a_12956_13412.n12 GND 0.01fF
C2769 a_12956_13412.n13 GND 0.01fF
C2770 a_12956_13412.n14 GND 0.01fF
C2771 a_12956_13412.n15 GND 0.00fF
C2772 a_12956_13412.n16 GND 0.00fF
C2773 a_12956_13412.n17 GND 0.00fF
C2774 a_12956_13412.t2 GND 0.02fF $ **FLOATING
C2775 a_12956_13412.n18 GND 0.07fF
C2776 a_12956_13412.n19 GND 0.02fF
C2777 a_12956_13412.n20 GND 0.05fF
C2778 a_12956_13412.n22 GND 0.04fF
C2779 a_12956_13412.n23 GND 0.04fF
C2780 a_12956_13412.n24 GND 0.00fF
C2781 a_12956_13412.n25 GND 0.00fF
C2782 a_12956_13412.t1 GND 0.02fF $ **FLOATING
C2783 a_12956_13412.n26 GND 0.07fF
C2784 a_12956_13412.n27 GND 0.02fF
C2785 a_12956_13412.n28 GND 0.05fF
C2786 a_12956_13412.n30 GND 0.01fF
C2787 a_12956_13412.n31 GND 0.00fF
C2788 a_12956_13412.n32 GND 0.01fF
C2789 a_12956_13412.n33 GND 0.00fF
C2790 a_12956_13412.n34 GND 0.00fF
C2791 a_12956_13412.n35 GND 0.00fF
C2792 a_12956_13412.n36 GND 0.00fF
C2793 a_12956_13412.n38 GND 0.08fF
C2794 a_12956_13412.t3 GND 4.25fF $ **FLOATING
C2795 a_12956_13412.n39 GND 0.62fF
C2796 a_12956_13412.t0 GND 0.26fF $ **FLOATING
C2797 a_20456_11582.n0 GND 0.00fF
C2798 a_20456_11582.n1 GND 0.00fF
C2799 a_20456_11582.n2 GND 0.01fF
C2800 a_20456_11582.n3 GND 0.01fF
C2801 a_20456_11582.n4 GND 0.00fF
C2802 a_20456_11582.n5 GND 0.01fF
C2803 a_20456_11582.n6 GND 0.00fF
C2804 a_20456_11582.n7 GND 0.00fF
C2805 a_20456_11582.n8 GND 0.00fF
C2806 a_20456_11582.n9 GND 0.00fF
C2807 a_20456_11582.n10 GND 0.09fF
C2808 a_20456_11582.n11 GND 0.00fF
C2809 a_20456_11582.n12 GND 0.01fF
C2810 a_20456_11582.n13 GND 0.01fF
C2811 a_20456_11582.n14 GND 0.01fF
C2812 a_20456_11582.n15 GND 0.00fF
C2813 a_20456_11582.n16 GND 0.00fF
C2814 a_20456_11582.n17 GND 0.00fF
C2815 a_20456_11582.t1 GND 0.02fF $ **FLOATING
C2816 a_20456_11582.n18 GND 0.07fF
C2817 a_20456_11582.n19 GND 0.02fF
C2818 a_20456_11582.n20 GND 0.05fF
C2819 a_20456_11582.n22 GND 0.04fF
C2820 a_20456_11582.n23 GND 0.04fF
C2821 a_20456_11582.n24 GND 0.00fF
C2822 a_20456_11582.n25 GND 0.00fF
C2823 a_20456_11582.t0 GND 0.02fF $ **FLOATING
C2824 a_20456_11582.n26 GND 0.07fF
C2825 a_20456_11582.n27 GND 0.02fF
C2826 a_20456_11582.n28 GND 0.05fF
C2827 a_20456_11582.n30 GND 0.01fF
C2828 a_20456_11582.n31 GND 0.00fF
C2829 a_20456_11582.n32 GND 0.01fF
C2830 a_20456_11582.n33 GND 0.00fF
C2831 a_20456_11582.n34 GND 0.00fF
C2832 a_20456_11582.n35 GND 0.00fF
C2833 a_20456_11582.n36 GND 0.00fF
C2834 a_20456_11582.n38 GND 0.08fF
C2835 a_20456_11582.t3 GND 4.25fF $ **FLOATING
C2836 a_20456_11582.n39 GND 0.62fF
C2837 a_20456_11582.t2 GND 0.26fF $ **FLOATING
C2838 a_27666_7846.n0 GND 0.01fF
C2839 a_27666_7846.n1 GND 0.01fF
C2840 a_27666_7846.n2 GND 0.00fF
C2841 a_27666_7846.n3 GND 0.00fF
C2842 a_27666_7846.n4 GND 0.00fF
C2843 a_27666_7846.n5 GND 0.00fF
C2844 a_27666_7846.n6 GND 0.00fF
C2845 a_27666_7846.n7 GND 0.00fF
C2846 a_27666_7846.n8 GND 0.00fF
C2847 a_27666_7846.n9 GND 0.00fF
C2848 a_27666_7846.t2 GND 0.02fF $ **FLOATING
C2849 a_27666_7846.t3 GND 0.02fF $ **FLOATING
C2850 a_27666_7846.n10 GND 0.05fF
C2851 a_27666_7846.n11 GND 0.00fF
C2852 a_27666_7846.n12 GND 0.00fF
C2853 a_27666_7846.n13 GND 0.02fF
C2854 a_27666_7846.n14 GND 0.05fF
C2855 a_27666_7846.n15 GND 0.13fF
C2856 a_27666_7846.n16 GND 0.01fF
C2857 a_27666_7846.n17 GND 0.12fF
C2858 a_27666_7846.t0 GND 3.94fF $ **FLOATING
C2859 a_27666_7846.n18 GND 0.53fF
C2860 a_27666_7846.t1 GND 0.24fF $ **FLOATING
C2861 a_12956_11582.n0 GND 0.00fF
C2862 a_12956_11582.n1 GND 0.00fF
C2863 a_12956_11582.n2 GND 0.01fF
C2864 a_12956_11582.n3 GND 0.01fF
C2865 a_12956_11582.n4 GND 0.00fF
C2866 a_12956_11582.n5 GND 0.01fF
C2867 a_12956_11582.n6 GND 0.00fF
C2868 a_12956_11582.n7 GND 0.00fF
C2869 a_12956_11582.n8 GND 0.00fF
C2870 a_12956_11582.n9 GND 0.00fF
C2871 a_12956_11582.n10 GND 0.09fF
C2872 a_12956_11582.n11 GND 0.00fF
C2873 a_12956_11582.n12 GND 0.01fF
C2874 a_12956_11582.n13 GND 0.01fF
C2875 a_12956_11582.n14 GND 0.01fF
C2876 a_12956_11582.n15 GND 0.00fF
C2877 a_12956_11582.n16 GND 0.00fF
C2878 a_12956_11582.n17 GND 0.00fF
C2879 a_12956_11582.t0 GND 0.02fF $ **FLOATING
C2880 a_12956_11582.n18 GND 0.07fF
C2881 a_12956_11582.n19 GND 0.02fF
C2882 a_12956_11582.n20 GND 0.05fF
C2883 a_12956_11582.n22 GND 0.04fF
C2884 a_12956_11582.n23 GND 0.04fF
C2885 a_12956_11582.n24 GND 0.00fF
C2886 a_12956_11582.n25 GND 0.00fF
C2887 a_12956_11582.t1 GND 0.02fF $ **FLOATING
C2888 a_12956_11582.n26 GND 0.07fF
C2889 a_12956_11582.n27 GND 0.02fF
C2890 a_12956_11582.n28 GND 0.05fF
C2891 a_12956_11582.n30 GND 0.01fF
C2892 a_12956_11582.n31 GND 0.00fF
C2893 a_12956_11582.n32 GND 0.01fF
C2894 a_12956_11582.n33 GND 0.00fF
C2895 a_12956_11582.n34 GND 0.00fF
C2896 a_12956_11582.n35 GND 0.00fF
C2897 a_12956_11582.n36 GND 0.00fF
C2898 a_12956_11582.n38 GND 0.08fF
C2899 a_12956_11582.t3 GND 4.25fF $ **FLOATING
C2900 a_12956_11582.n39 GND 0.62fF
C2901 a_12956_11582.t2 GND 0.26fF $ **FLOATING
C2902 a_20166_7846.n0 GND 0.01fF
C2903 a_20166_7846.n1 GND 0.01fF
C2904 a_20166_7846.n2 GND 0.00fF
C2905 a_20166_7846.n3 GND 0.00fF
C2906 a_20166_7846.n4 GND 0.00fF
C2907 a_20166_7846.n5 GND 0.00fF
C2908 a_20166_7846.n6 GND 0.00fF
C2909 a_20166_7846.n7 GND 0.00fF
C2910 a_20166_7846.n8 GND 0.00fF
C2911 a_20166_7846.n9 GND 0.00fF
C2912 a_20166_7846.t2 GND 0.02fF $ **FLOATING
C2913 a_20166_7846.t3 GND 0.02fF $ **FLOATING
C2914 a_20166_7846.n10 GND 0.05fF
C2915 a_20166_7846.n11 GND 0.00fF
C2916 a_20166_7846.n12 GND 0.00fF
C2917 a_20166_7846.n13 GND 0.02fF
C2918 a_20166_7846.n14 GND 0.05fF
C2919 a_20166_7846.n15 GND 0.13fF
C2920 a_20166_7846.n16 GND 0.01fF
C2921 a_20166_7846.n17 GND 0.12fF
C2922 a_20166_7846.t0 GND 3.94fF $ **FLOATING
C2923 a_20166_7846.n18 GND 0.53fF
C2924 a_20166_7846.t1 GND 0.24fF $ **FLOATING
C2925 a_23916_4186.n0 GND 0.01fF
C2926 a_23916_4186.n1 GND 0.01fF
C2927 a_23916_4186.n2 GND 0.00fF
C2928 a_23916_4186.n3 GND 0.00fF
C2929 a_23916_4186.n4 GND 0.00fF
C2930 a_23916_4186.n5 GND 0.00fF
C2931 a_23916_4186.n6 GND 0.00fF
C2932 a_23916_4186.n7 GND 0.00fF
C2933 a_23916_4186.n8 GND 0.00fF
C2934 a_23916_4186.n9 GND 0.00fF
C2935 a_23916_4186.t2 GND 0.02fF $ **FLOATING
C2936 a_23916_4186.t3 GND 0.02fF $ **FLOATING
C2937 a_23916_4186.n10 GND 0.05fF
C2938 a_23916_4186.n11 GND 0.00fF
C2939 a_23916_4186.n12 GND 0.00fF
C2940 a_23916_4186.n13 GND 0.02fF
C2941 a_23916_4186.n14 GND 0.05fF
C2942 a_23916_4186.n15 GND 0.13fF
C2943 a_23916_4186.n16 GND 0.01fF
C2944 a_23916_4186.n17 GND 0.12fF
C2945 a_23916_4186.t0 GND 3.94fF $ **FLOATING
C2946 a_23916_4186.n18 GND 0.53fF
C2947 a_23916_4186.t1 GND 0.24fF $ **FLOATING
C2948 a_16416_2356.n0 GND 0.01fF
C2949 a_16416_2356.n1 GND 0.01fF
C2950 a_16416_2356.n2 GND 0.00fF
C2951 a_16416_2356.n3 GND 0.00fF
C2952 a_16416_2356.n4 GND 0.00fF
C2953 a_16416_2356.n5 GND 0.00fF
C2954 a_16416_2356.n6 GND 0.00fF
C2955 a_16416_2356.n7 GND 0.00fF
C2956 a_16416_2356.n8 GND 0.00fF
C2957 a_16416_2356.n9 GND 0.00fF
C2958 a_16416_2356.t2 GND 0.02fF $ **FLOATING
C2959 a_16416_2356.t3 GND 0.02fF $ **FLOATING
C2960 a_16416_2356.n10 GND 0.05fF
C2961 a_16416_2356.n11 GND 0.00fF
C2962 a_16416_2356.n12 GND 0.00fF
C2963 a_16416_2356.n13 GND 0.02fF
C2964 a_16416_2356.n14 GND 0.05fF
C2965 a_16416_2356.n15 GND 0.13fF
C2966 a_16416_2356.n16 GND 0.01fF
C2967 a_16416_2356.n17 GND 0.12fF
C2968 a_16416_2356.t1 GND 3.94fF $ **FLOATING
C2969 a_16416_2356.n18 GND 0.53fF
C2970 a_16416_2356.t0 GND 0.24fF $ **FLOATING
C2971 a_16706_2432.n0 GND 0.00fF
C2972 a_16706_2432.n1 GND 0.00fF
C2973 a_16706_2432.n2 GND 0.01fF
C2974 a_16706_2432.n3 GND 0.01fF
C2975 a_16706_2432.n4 GND 0.00fF
C2976 a_16706_2432.n5 GND 0.01fF
C2977 a_16706_2432.n6 GND 0.00fF
C2978 a_16706_2432.n7 GND 0.00fF
C2979 a_16706_2432.n8 GND 0.00fF
C2980 a_16706_2432.n9 GND 0.00fF
C2981 a_16706_2432.n10 GND 0.09fF
C2982 a_16706_2432.n11 GND 0.00fF
C2983 a_16706_2432.n12 GND 0.01fF
C2984 a_16706_2432.n13 GND 0.01fF
C2985 a_16706_2432.n14 GND 0.01fF
C2986 a_16706_2432.n15 GND 0.00fF
C2987 a_16706_2432.n16 GND 0.00fF
C2988 a_16706_2432.n17 GND 0.00fF
C2989 a_16706_2432.t2 GND 0.02fF $ **FLOATING
C2990 a_16706_2432.n18 GND 0.07fF
C2991 a_16706_2432.n19 GND 0.02fF
C2992 a_16706_2432.n20 GND 0.05fF
C2993 a_16706_2432.n22 GND 0.04fF
C2994 a_16706_2432.n23 GND 0.04fF
C2995 a_16706_2432.n24 GND 0.00fF
C2996 a_16706_2432.n25 GND 0.00fF
C2997 a_16706_2432.t1 GND 0.02fF $ **FLOATING
C2998 a_16706_2432.n26 GND 0.07fF
C2999 a_16706_2432.n27 GND 0.02fF
C3000 a_16706_2432.n28 GND 0.05fF
C3001 a_16706_2432.n30 GND 0.01fF
C3002 a_16706_2432.n31 GND 0.00fF
C3003 a_16706_2432.n32 GND 0.01fF
C3004 a_16706_2432.n33 GND 0.00fF
C3005 a_16706_2432.n34 GND 0.00fF
C3006 a_16706_2432.n35 GND 0.00fF
C3007 a_16706_2432.n36 GND 0.00fF
C3008 a_16706_2432.n38 GND 0.08fF
C3009 a_16706_2432.t3 GND 4.25fF $ **FLOATING
C3010 a_16706_2432.n39 GND 0.62fF
C3011 a_16706_2432.t0 GND 0.26fF $ **FLOATING
C3012 a_1706_4262.n0 GND 0.00fF
C3013 a_1706_4262.n1 GND 0.00fF
C3014 a_1706_4262.n2 GND 0.01fF
C3015 a_1706_4262.n3 GND 0.01fF
C3016 a_1706_4262.n4 GND 0.00fF
C3017 a_1706_4262.n5 GND 0.01fF
C3018 a_1706_4262.n6 GND 0.00fF
C3019 a_1706_4262.n7 GND 0.00fF
C3020 a_1706_4262.n8 GND 0.00fF
C3021 a_1706_4262.n9 GND 0.00fF
C3022 a_1706_4262.n10 GND 0.09fF
C3023 a_1706_4262.n11 GND 0.00fF
C3024 a_1706_4262.n12 GND 0.01fF
C3025 a_1706_4262.n13 GND 0.01fF
C3026 a_1706_4262.n14 GND 0.01fF
C3027 a_1706_4262.n15 GND 0.00fF
C3028 a_1706_4262.n16 GND 0.00fF
C3029 a_1706_4262.n17 GND 0.00fF
C3030 a_1706_4262.t1 GND 0.02fF $ **FLOATING
C3031 a_1706_4262.n18 GND 0.07fF
C3032 a_1706_4262.n19 GND 0.02fF
C3033 a_1706_4262.n20 GND 0.05fF
C3034 a_1706_4262.n22 GND 0.04fF
C3035 a_1706_4262.n23 GND 0.04fF
C3036 a_1706_4262.n24 GND 0.00fF
C3037 a_1706_4262.n25 GND 0.00fF
C3038 a_1706_4262.t2 GND 0.02fF $ **FLOATING
C3039 a_1706_4262.n26 GND 0.07fF
C3040 a_1706_4262.n27 GND 0.02fF
C3041 a_1706_4262.n28 GND 0.05fF
C3042 a_1706_4262.n30 GND 0.01fF
C3043 a_1706_4262.n31 GND 0.00fF
C3044 a_1706_4262.n32 GND 0.01fF
C3045 a_1706_4262.n33 GND 0.00fF
C3046 a_1706_4262.n34 GND 0.00fF
C3047 a_1706_4262.n35 GND 0.00fF
C3048 a_1706_4262.n36 GND 0.00fF
C3049 a_1706_4262.n38 GND 0.08fF
C3050 a_1706_4262.t3 GND 4.25fF $ **FLOATING
C3051 a_1706_4262.n39 GND 0.62fF
C3052 a_1706_4262.t0 GND 0.26fF $ **FLOATING
C3053 a_16416_4186.n0 GND 0.01fF
C3054 a_16416_4186.n1 GND 0.01fF
C3055 a_16416_4186.n2 GND 0.00fF
C3056 a_16416_4186.n3 GND 0.00fF
C3057 a_16416_4186.n4 GND 0.00fF
C3058 a_16416_4186.n5 GND 0.00fF
C3059 a_16416_4186.n6 GND 0.00fF
C3060 a_16416_4186.n7 GND 0.00fF
C3061 a_16416_4186.n8 GND 0.00fF
C3062 a_16416_4186.n9 GND 0.00fF
C3063 a_16416_4186.t3 GND 0.02fF $ **FLOATING
C3064 a_16416_4186.t2 GND 0.02fF $ **FLOATING
C3065 a_16416_4186.n10 GND 0.05fF
C3066 a_16416_4186.n11 GND 0.00fF
C3067 a_16416_4186.n12 GND 0.00fF
C3068 a_16416_4186.n13 GND 0.02fF
C3069 a_16416_4186.n14 GND 0.05fF
C3070 a_16416_4186.n15 GND 0.13fF
C3071 a_16416_4186.n16 GND 0.01fF
C3072 a_16416_4186.n17 GND 0.12fF
C3073 a_16416_4186.t0 GND 3.94fF $ **FLOATING
C3074 a_16416_4186.n18 GND 0.53fF
C3075 a_16416_4186.t1 GND 0.24fF $ **FLOATING
C3076 a_20166_526.n0 GND 0.01fF
C3077 a_20166_526.n1 GND 0.01fF
C3078 a_20166_526.n2 GND 0.00fF
C3079 a_20166_526.n3 GND 0.00fF
C3080 a_20166_526.n4 GND 0.00fF
C3081 a_20166_526.n5 GND 0.00fF
C3082 a_20166_526.n6 GND 0.00fF
C3083 a_20166_526.n7 GND 0.00fF
C3084 a_20166_526.n8 GND 0.00fF
C3085 a_20166_526.n9 GND 0.00fF
C3086 a_20166_526.t2 GND 0.02fF $ **FLOATING
C3087 a_20166_526.t3 GND 0.02fF $ **FLOATING
C3088 a_20166_526.n10 GND 0.05fF
C3089 a_20166_526.n11 GND 0.00fF
C3090 a_20166_526.n12 GND 0.00fF
C3091 a_20166_526.n13 GND 0.02fF
C3092 a_20166_526.n14 GND 0.05fF
C3093 a_20166_526.n15 GND 0.13fF
C3094 a_20166_526.n16 GND 0.01fF
C3095 a_20166_526.n17 GND 0.12fF
C3096 a_20166_526.t0 GND 3.94fF $ **FLOATING
C3097 a_20166_526.n18 GND 0.53fF
C3098 a_20166_526.t1 GND 0.24fF $ **FLOATING
C3099 a_12666_2356.n0 GND 0.01fF
C3100 a_12666_2356.n1 GND 0.01fF
C3101 a_12666_2356.n2 GND 0.00fF
C3102 a_12666_2356.n3 GND 0.00fF
C3103 a_12666_2356.n4 GND 0.00fF
C3104 a_12666_2356.n5 GND 0.00fF
C3105 a_12666_2356.n6 GND 0.00fF
C3106 a_12666_2356.n7 GND 0.00fF
C3107 a_12666_2356.n8 GND 0.00fF
C3108 a_12666_2356.n9 GND 0.00fF
C3109 a_12666_2356.t2 GND 0.02fF $ **FLOATING
C3110 a_12666_2356.t3 GND 0.02fF $ **FLOATING
C3111 a_12666_2356.n10 GND 0.05fF
C3112 a_12666_2356.n11 GND 0.00fF
C3113 a_12666_2356.n12 GND 0.00fF
C3114 a_12666_2356.n13 GND 0.02fF
C3115 a_12666_2356.n14 GND 0.05fF
C3116 a_12666_2356.n15 GND 0.13fF
C3117 a_12666_2356.n16 GND 0.01fF
C3118 a_12666_2356.n17 GND 0.12fF
C3119 a_12666_2356.t0 GND 3.94fF $ **FLOATING
C3120 a_12666_2356.n18 GND 0.53fF
C3121 a_12666_2356.t1 GND 0.24fF $ **FLOATING
C3122 a_27956_2432.n0 GND 0.00fF
C3123 a_27956_2432.n1 GND 0.00fF
C3124 a_27956_2432.n2 GND 0.01fF
C3125 a_27956_2432.n3 GND 0.01fF
C3126 a_27956_2432.n4 GND 0.00fF
C3127 a_27956_2432.n5 GND 0.01fF
C3128 a_27956_2432.n6 GND 0.00fF
C3129 a_27956_2432.n7 GND 0.00fF
C3130 a_27956_2432.n8 GND 0.00fF
C3131 a_27956_2432.n9 GND 0.00fF
C3132 a_27956_2432.n10 GND 0.09fF
C3133 a_27956_2432.n11 GND 0.00fF
C3134 a_27956_2432.n12 GND 0.01fF
C3135 a_27956_2432.n13 GND 0.01fF
C3136 a_27956_2432.n14 GND 0.01fF
C3137 a_27956_2432.n15 GND 0.00fF
C3138 a_27956_2432.n16 GND 0.00fF
C3139 a_27956_2432.n17 GND 0.00fF
C3140 a_27956_2432.t2 GND 0.02fF $ **FLOATING
C3141 a_27956_2432.n18 GND 0.07fF
C3142 a_27956_2432.n19 GND 0.02fF
C3143 a_27956_2432.n20 GND 0.05fF
C3144 a_27956_2432.n22 GND 0.04fF
C3145 a_27956_2432.n23 GND 0.04fF
C3146 a_27956_2432.n24 GND 0.00fF
C3147 a_27956_2432.n25 GND 0.00fF
C3148 a_27956_2432.t1 GND 0.02fF $ **FLOATING
C3149 a_27956_2432.n26 GND 0.07fF
C3150 a_27956_2432.n27 GND 0.02fF
C3151 a_27956_2432.n28 GND 0.05fF
C3152 a_27956_2432.n30 GND 0.01fF
C3153 a_27956_2432.n31 GND 0.00fF
C3154 a_27956_2432.n32 GND 0.01fF
C3155 a_27956_2432.n33 GND 0.00fF
C3156 a_27956_2432.n34 GND 0.00fF
C3157 a_27956_2432.n35 GND 0.00fF
C3158 a_27956_2432.n36 GND 0.00fF
C3159 a_27956_2432.n38 GND 0.08fF
C3160 a_27956_2432.t3 GND 4.25fF $ **FLOATING
C3161 a_27956_2432.n39 GND 0.62fF
C3162 a_27956_2432.t0 GND 0.26fF $ **FLOATING
C3163 a_5456_602.n0 GND 0.00fF
C3164 a_5456_602.n1 GND 0.00fF
C3165 a_5456_602.n2 GND 0.01fF
C3166 a_5456_602.n3 GND 0.01fF
C3167 a_5456_602.n4 GND 0.00fF
C3168 a_5456_602.n5 GND 0.01fF
C3169 a_5456_602.n6 GND 0.00fF
C3170 a_5456_602.n7 GND 0.00fF
C3171 a_5456_602.n8 GND 0.00fF
C3172 a_5456_602.n9 GND 0.00fF
C3173 a_5456_602.n10 GND 0.09fF
C3174 a_5456_602.n11 GND 0.00fF
C3175 a_5456_602.n12 GND 0.01fF
C3176 a_5456_602.n13 GND 0.01fF
C3177 a_5456_602.n14 GND 0.01fF
C3178 a_5456_602.n15 GND 0.00fF
C3179 a_5456_602.n16 GND 0.00fF
C3180 a_5456_602.n17 GND 0.00fF
C3181 a_5456_602.t2 GND 0.02fF $ **FLOATING
C3182 a_5456_602.n18 GND 0.07fF
C3183 a_5456_602.n19 GND 0.02fF
C3184 a_5456_602.n20 GND 0.05fF
C3185 a_5456_602.n22 GND 0.04fF
C3186 a_5456_602.n23 GND 0.04fF
C3187 a_5456_602.n24 GND 0.00fF
C3188 a_5456_602.n25 GND 0.00fF
C3189 a_5456_602.t1 GND 0.02fF $ **FLOATING
C3190 a_5456_602.n26 GND 0.07fF
C3191 a_5456_602.n27 GND 0.02fF
C3192 a_5456_602.n28 GND 0.05fF
C3193 a_5456_602.n30 GND 0.01fF
C3194 a_5456_602.n31 GND 0.00fF
C3195 a_5456_602.n32 GND 0.01fF
C3196 a_5456_602.n33 GND 0.00fF
C3197 a_5456_602.n34 GND 0.00fF
C3198 a_5456_602.n35 GND 0.00fF
C3199 a_5456_602.n36 GND 0.00fF
C3200 a_5456_602.n38 GND 0.08fF
C3201 a_5456_602.t3 GND 4.25fF $ **FLOATING
C3202 a_5456_602.n39 GND 0.62fF
C3203 a_5456_602.t0 GND 0.26fF $ **FLOATING
C3204 bit0.t2 GND 0.06fF $ **FLOATING
C3205 bit0.t0 GND 0.03fF $ **FLOATING
C3206 bit0.n0 GND 0.07fF
C3207 bit0.n1 GND 0.01fF
C3208 bit0.n2 GND 0.01fF
C3209 bit0.t3 GND 0.11fF $ **FLOATING
C3210 bit0.n3 GND 0.03fF
C3211 bit0.n4 GND 0.01fF
C3212 bit0.t1 GND 0.11fF $ **FLOATING
C3213 bit0.n5 GND 0.03fF
C3214 bit0.n6 GND 0.02fF
C3215 bit0.n7 GND 0.32fF
C3216 bit0.n8 GND 6.58fF
C3217 a_27666_2356.n0 GND 0.01fF
C3218 a_27666_2356.n1 GND 0.01fF
C3219 a_27666_2356.n2 GND 0.00fF
C3220 a_27666_2356.n3 GND 0.00fF
C3221 a_27666_2356.n4 GND 0.00fF
C3222 a_27666_2356.n5 GND 0.00fF
C3223 a_27666_2356.n6 GND 0.00fF
C3224 a_27666_2356.n7 GND 0.00fF
C3225 a_27666_2356.n8 GND 0.00fF
C3226 a_27666_2356.n9 GND 0.00fF
C3227 a_27666_2356.t2 GND 0.02fF $ **FLOATING
C3228 a_27666_2356.t3 GND 0.02fF $ **FLOATING
C3229 a_27666_2356.n10 GND 0.05fF
C3230 a_27666_2356.n11 GND 0.00fF
C3231 a_27666_2356.n12 GND 0.00fF
C3232 a_27666_2356.n13 GND 0.02fF
C3233 a_27666_2356.n14 GND 0.05fF
C3234 a_27666_2356.n15 GND 0.13fF
C3235 a_27666_2356.n16 GND 0.01fF
C3236 a_27666_2356.n17 GND 0.12fF
C3237 a_27666_2356.t1 GND 3.94fF $ **FLOATING
C3238 a_27666_2356.n18 GND 0.53fF
C3239 a_27666_2356.t0 GND 0.24fF $ **FLOATING
C3240 a_24206_4262.n0 GND 0.00fF
C3241 a_24206_4262.n1 GND 0.00fF
C3242 a_24206_4262.n2 GND 0.01fF
C3243 a_24206_4262.n3 GND 0.01fF
C3244 a_24206_4262.n4 GND 0.00fF
C3245 a_24206_4262.n5 GND 0.01fF
C3246 a_24206_4262.n6 GND 0.00fF
C3247 a_24206_4262.n7 GND 0.00fF
C3248 a_24206_4262.n8 GND 0.00fF
C3249 a_24206_4262.n9 GND 0.00fF
C3250 a_24206_4262.n10 GND 0.09fF
C3251 a_24206_4262.n11 GND 0.00fF
C3252 a_24206_4262.n12 GND 0.01fF
C3253 a_24206_4262.n13 GND 0.01fF
C3254 a_24206_4262.n14 GND 0.01fF
C3255 a_24206_4262.n15 GND 0.00fF
C3256 a_24206_4262.n16 GND 0.00fF
C3257 a_24206_4262.n17 GND 0.00fF
C3258 a_24206_4262.t2 GND 0.02fF $ **FLOATING
C3259 a_24206_4262.n18 GND 0.07fF
C3260 a_24206_4262.n19 GND 0.02fF
C3261 a_24206_4262.n20 GND 0.05fF
C3262 a_24206_4262.n22 GND 0.04fF
C3263 a_24206_4262.n23 GND 0.04fF
C3264 a_24206_4262.n24 GND 0.00fF
C3265 a_24206_4262.n25 GND 0.00fF
C3266 a_24206_4262.t1 GND 0.02fF $ **FLOATING
C3267 a_24206_4262.n26 GND 0.07fF
C3268 a_24206_4262.n27 GND 0.02fF
C3269 a_24206_4262.n28 GND 0.05fF
C3270 a_24206_4262.n30 GND 0.01fF
C3271 a_24206_4262.n31 GND 0.00fF
C3272 a_24206_4262.n32 GND 0.01fF
C3273 a_24206_4262.n33 GND 0.00fF
C3274 a_24206_4262.n34 GND 0.00fF
C3275 a_24206_4262.n35 GND 0.00fF
C3276 a_24206_4262.n36 GND 0.00fF
C3277 a_24206_4262.n38 GND 0.08fF
C3278 a_24206_4262.t3 GND 4.25fF $ **FLOATING
C3279 a_24206_4262.n39 GND 0.62fF
C3280 a_24206_4262.t0 GND 0.26fF $ **FLOATING
C3281 a_12666_13336.n0 GND 0.01fF
C3282 a_12666_13336.n1 GND 0.01fF
C3283 a_12666_13336.n2 GND 0.00fF
C3284 a_12666_13336.n3 GND 0.00fF
C3285 a_12666_13336.n4 GND 0.00fF
C3286 a_12666_13336.n5 GND 0.00fF
C3287 a_12666_13336.n6 GND 0.00fF
C3288 a_12666_13336.n7 GND 0.00fF
C3289 a_12666_13336.n8 GND 0.00fF
C3290 a_12666_13336.n9 GND 0.00fF
C3291 a_12666_13336.t2 GND 0.02fF $ **FLOATING
C3292 a_12666_13336.t3 GND 0.02fF $ **FLOATING
C3293 a_12666_13336.n10 GND 0.05fF
C3294 a_12666_13336.n11 GND 0.00fF
C3295 a_12666_13336.n12 GND 0.00fF
C3296 a_12666_13336.n13 GND 0.02fF
C3297 a_12666_13336.n14 GND 0.05fF
C3298 a_12666_13336.n15 GND 0.13fF
C3299 a_12666_13336.n16 GND 0.01fF
C3300 a_12666_13336.n17 GND 0.12fF
C3301 a_12666_13336.t1 GND 3.94fF $ **FLOATING
C3302 a_12666_13336.n18 GND 0.53fF
C3303 a_12666_13336.t0 GND 0.24fF $ **FLOATING
C3304 a_20456_9752.n0 GND 0.00fF
C3305 a_20456_9752.n1 GND 0.00fF
C3306 a_20456_9752.n2 GND 0.01fF
C3307 a_20456_9752.n3 GND 0.01fF
C3308 a_20456_9752.n4 GND 0.00fF
C3309 a_20456_9752.n5 GND 0.01fF
C3310 a_20456_9752.n6 GND 0.00fF
C3311 a_20456_9752.n7 GND 0.00fF
C3312 a_20456_9752.n8 GND 0.00fF
C3313 a_20456_9752.n9 GND 0.00fF
C3314 a_20456_9752.n10 GND 0.09fF
C3315 a_20456_9752.n11 GND 0.00fF
C3316 a_20456_9752.n12 GND 0.01fF
C3317 a_20456_9752.n13 GND 0.01fF
C3318 a_20456_9752.n14 GND 0.01fF
C3319 a_20456_9752.n15 GND 0.00fF
C3320 a_20456_9752.n16 GND 0.00fF
C3321 a_20456_9752.n17 GND 0.00fF
C3322 a_20456_9752.t3 GND 0.02fF $ **FLOATING
C3323 a_20456_9752.n18 GND 0.07fF
C3324 a_20456_9752.n19 GND 0.02fF
C3325 a_20456_9752.n20 GND 0.05fF
C3326 a_20456_9752.n22 GND 0.04fF
C3327 a_20456_9752.n23 GND 0.04fF
C3328 a_20456_9752.n24 GND 0.00fF
C3329 a_20456_9752.n25 GND 0.00fF
C3330 a_20456_9752.t2 GND 0.02fF $ **FLOATING
C3331 a_20456_9752.n26 GND 0.07fF
C3332 a_20456_9752.n27 GND 0.02fF
C3333 a_20456_9752.n28 GND 0.05fF
C3334 a_20456_9752.n30 GND 0.01fF
C3335 a_20456_9752.n31 GND 0.00fF
C3336 a_20456_9752.n32 GND 0.01fF
C3337 a_20456_9752.n33 GND 0.00fF
C3338 a_20456_9752.n34 GND 0.00fF
C3339 a_20456_9752.n35 GND 0.00fF
C3340 a_20456_9752.n36 GND 0.00fF
C3341 a_20456_9752.n38 GND 0.08fF
C3342 a_20456_9752.t1 GND 4.25fF $ **FLOATING
C3343 a_20456_9752.n39 GND 0.62fF
C3344 a_20456_9752.t0 GND 0.26fF $ **FLOATING
C3345 a_12666_11506.n0 GND 0.01fF
C3346 a_12666_11506.n1 GND 0.01fF
C3347 a_12666_11506.n2 GND 0.00fF
C3348 a_12666_11506.n3 GND 0.00fF
C3349 a_12666_11506.n4 GND 0.00fF
C3350 a_12666_11506.n5 GND 0.00fF
C3351 a_12666_11506.n6 GND 0.00fF
C3352 a_12666_11506.n7 GND 0.00fF
C3353 a_12666_11506.n8 GND 0.00fF
C3354 a_12666_11506.n9 GND 0.00fF
C3355 a_12666_11506.t2 GND 0.02fF $ **FLOATING
C3356 a_12666_11506.t1 GND 0.02fF $ **FLOATING
C3357 a_12666_11506.n10 GND 0.05fF
C3358 a_12666_11506.n11 GND 0.00fF
C3359 a_12666_11506.n12 GND 0.00fF
C3360 a_12666_11506.n13 GND 0.02fF
C3361 a_12666_11506.n14 GND 0.05fF
C3362 a_12666_11506.n15 GND 0.13fF
C3363 a_12666_11506.n16 GND 0.01fF
C3364 a_12666_11506.n17 GND 0.12fF
C3365 a_12666_11506.t0 GND 3.94fF $ **FLOATING
C3366 a_12666_11506.n18 GND 0.53fF
C3367 a_12666_11506.t3 GND 0.24fF $ **FLOATING
C3368 a_n456_10986.t6 GND 0.13fF $ **FLOATING
C3369 a_n456_10986.t0 GND 0.23fF $ **FLOATING
C3370 a_n456_10986.t11 GND 0.23fF $ **FLOATING
C3371 a_n456_10986.t12 GND 0.23fF $ **FLOATING
C3372 a_n456_10986.t3 GND 0.23fF $ **FLOATING
C3373 a_n456_10986.t4 GND 0.23fF $ **FLOATING
C3374 a_n456_10986.t2 GND 0.23fF $ **FLOATING
C3375 a_n456_10986.t17 GND 0.23fF $ **FLOATING
C3376 a_n456_10986.t14 GND 0.23fF $ **FLOATING
C3377 a_n456_10986.t10 GND 0.23fF $ **FLOATING
C3378 a_n456_10986.t13 GND 0.23fF $ **FLOATING
C3379 a_n456_10986.t1 GND 0.23fF $ **FLOATING
C3380 a_n456_10986.t8 GND 0.23fF $ **FLOATING
C3381 a_n456_10986.t16 GND 0.23fF $ **FLOATING
C3382 a_n456_10986.t5 GND 0.23fF $ **FLOATING
C3383 a_n456_10986.t15 GND 0.23fF $ **FLOATING
C3384 a_n456_10986.t9 GND 0.30fF $ **FLOATING
C3385 a_n456_10986.n0 GND 2.33fF
C3386 a_n456_10986.n1 GND 1.19fF
C3387 a_n456_10986.n2 GND 1.19fF
C3388 a_n456_10986.n3 GND 1.19fF
C3389 a_n456_10986.n4 GND 1.19fF
C3390 a_n456_10986.n5 GND 1.19fF
C3391 a_n456_10986.n6 GND 1.19fF
C3392 a_n456_10986.n7 GND 1.19fF
C3393 a_n456_10986.n8 GND 1.19fF
C3394 a_n456_10986.n9 GND 1.19fF
C3395 a_n456_10986.n10 GND 1.19fF
C3396 a_n456_10986.n11 GND 1.19fF
C3397 a_n456_10986.n12 GND 1.19fF
C3398 a_n456_10986.n13 GND 1.19fF
C3399 a_n456_10986.n14 GND 1.76fF
C3400 a_n456_10986.n15 GND 0.12fF
C3401 a_n456_10986.t7 GND 0.28fF $ **FLOATING
C3402 a_24206_11582.n0 GND 0.00fF
C3403 a_24206_11582.n1 GND 0.00fF
C3404 a_24206_11582.n2 GND 0.01fF
C3405 a_24206_11582.n3 GND 0.01fF
C3406 a_24206_11582.n4 GND 0.00fF
C3407 a_24206_11582.n5 GND 0.01fF
C3408 a_24206_11582.n6 GND 0.00fF
C3409 a_24206_11582.n7 GND 0.00fF
C3410 a_24206_11582.n8 GND 0.00fF
C3411 a_24206_11582.n9 GND 0.00fF
C3412 a_24206_11582.n10 GND 0.09fF
C3413 a_24206_11582.n11 GND 0.00fF
C3414 a_24206_11582.n12 GND 0.01fF
C3415 a_24206_11582.n13 GND 0.01fF
C3416 a_24206_11582.n14 GND 0.01fF
C3417 a_24206_11582.n15 GND 0.00fF
C3418 a_24206_11582.n16 GND 0.00fF
C3419 a_24206_11582.n17 GND 0.00fF
C3420 a_24206_11582.t1 GND 0.02fF $ **FLOATING
C3421 a_24206_11582.n18 GND 0.07fF
C3422 a_24206_11582.n19 GND 0.02fF
C3423 a_24206_11582.n20 GND 0.05fF
C3424 a_24206_11582.n22 GND 0.04fF
C3425 a_24206_11582.n23 GND 0.04fF
C3426 a_24206_11582.n24 GND 0.00fF
C3427 a_24206_11582.n25 GND 0.00fF
C3428 a_24206_11582.t2 GND 0.02fF $ **FLOATING
C3429 a_24206_11582.n26 GND 0.07fF
C3430 a_24206_11582.n27 GND 0.02fF
C3431 a_24206_11582.n28 GND 0.05fF
C3432 a_24206_11582.n30 GND 0.01fF
C3433 a_24206_11582.n31 GND 0.00fF
C3434 a_24206_11582.n32 GND 0.01fF
C3435 a_24206_11582.n33 GND 0.00fF
C3436 a_24206_11582.n34 GND 0.00fF
C3437 a_24206_11582.n35 GND 0.00fF
C3438 a_24206_11582.n36 GND 0.00fF
C3439 a_24206_11582.n38 GND 0.08fF
C3440 a_24206_11582.t3 GND 4.25fF $ **FLOATING
C3441 a_24206_11582.n39 GND 0.62fF
C3442 a_24206_11582.t0 GND 0.26fF $ **FLOATING
C3443 a_1416_15166.n0 GND 0.01fF
C3444 a_1416_15166.n1 GND 0.01fF
C3445 a_1416_15166.n2 GND 0.00fF
C3446 a_1416_15166.n3 GND 0.00fF
C3447 a_1416_15166.n4 GND 0.00fF
C3448 a_1416_15166.n5 GND 0.00fF
C3449 a_1416_15166.n6 GND 0.00fF
C3450 a_1416_15166.n7 GND 0.00fF
C3451 a_1416_15166.n8 GND 0.00fF
C3452 a_1416_15166.n9 GND 0.00fF
C3453 a_1416_15166.t2 GND 0.02fF $ **FLOATING
C3454 a_1416_15166.t3 GND 0.02fF $ **FLOATING
C3455 a_1416_15166.n10 GND 0.05fF
C3456 a_1416_15166.n11 GND 0.00fF
C3457 a_1416_15166.n12 GND 0.00fF
C3458 a_1416_15166.n13 GND 0.02fF
C3459 a_1416_15166.n14 GND 0.05fF
C3460 a_1416_15166.n15 GND 0.13fF
C3461 a_1416_15166.n16 GND 0.01fF
C3462 a_1416_15166.n17 GND 0.12fF
C3463 a_1416_15166.t1 GND 3.94fF $ **FLOATING
C3464 a_1416_15166.n18 GND 0.53fF
C3465 a_1416_15166.t0 GND 0.24fF $ **FLOATING
C3466 bit1.t1 GND 0.06fF $ **FLOATING
C3467 bit1.t3 GND 0.03fF $ **FLOATING
C3468 bit1.n0 GND 0.07fF
C3469 bit1.n1 GND 0.01fF
C3470 bit1.n2 GND 0.01fF
C3471 bit1.t0 GND 0.11fF $ **FLOATING
C3472 bit1.n3 GND 0.03fF
C3473 bit1.n4 GND 0.01fF
C3474 bit1.t5 GND 0.11fF $ **FLOATING
C3475 bit1.n5 GND 0.03fF
C3476 bit1.n6 GND 0.02fF
C3477 bit1.n7 GND 0.33fF
C3478 bit1.n8 GND 1.91fF
C3479 bit1.t2 GND 0.11fF $ **FLOATING
C3480 bit1.n9 GND 0.03fF
C3481 bit1.n10 GND 0.02fF
C3482 bit1.t4 GND 0.11fF $ **FLOATING
C3483 bit1.n11 GND 0.03fF
C3484 bit1.n12 GND 0.01fF
C3485 bit1.n13 GND 0.01fF
C3486 bit1.n14 GND 0.01fF
C3487 bit1.n15 GND 0.33fF
C3488 bit1.n16 GND 5.73fF
C3489 a_n456_14646.t1 GND 0.15fF $ **FLOATING
C3490 a_n456_14646.t4 GND 0.25fF $ **FLOATING
C3491 a_n456_14646.t2 GND 0.25fF $ **FLOATING
C3492 a_n456_14646.t3 GND 0.25fF $ **FLOATING
C3493 a_n456_14646.t5 GND 0.33fF $ **FLOATING
C3494 a_n456_14646.n0 GND 2.59fF
C3495 a_n456_14646.n1 GND 1.32fF
C3496 a_n456_14646.n2 GND 1.95fF
C3497 a_n456_14646.n3 GND 0.13fF
C3498 a_n456_14646.t0 GND 0.31fF $ **FLOATING
C3499 a_5456_15242.n0 GND 0.00fF
C3500 a_5456_15242.n1 GND 0.00fF
C3501 a_5456_15242.n2 GND 0.01fF
C3502 a_5456_15242.n3 GND 0.01fF
C3503 a_5456_15242.n4 GND 0.00fF
C3504 a_5456_15242.n5 GND 0.01fF
C3505 a_5456_15242.n6 GND 0.00fF
C3506 a_5456_15242.n7 GND 0.00fF
C3507 a_5456_15242.n8 GND 0.00fF
C3508 a_5456_15242.n9 GND 0.00fF
C3509 a_5456_15242.n10 GND 0.09fF
C3510 a_5456_15242.n11 GND 0.00fF
C3511 a_5456_15242.n12 GND 0.01fF
C3512 a_5456_15242.n13 GND 0.01fF
C3513 a_5456_15242.n14 GND 0.01fF
C3514 a_5456_15242.n15 GND 0.00fF
C3515 a_5456_15242.n16 GND 0.00fF
C3516 a_5456_15242.n17 GND 0.00fF
C3517 a_5456_15242.t0 GND 0.02fF $ **FLOATING
C3518 a_5456_15242.n18 GND 0.07fF
C3519 a_5456_15242.n19 GND 0.02fF
C3520 a_5456_15242.n20 GND 0.05fF
C3521 a_5456_15242.n22 GND 0.04fF
C3522 a_5456_15242.n23 GND 0.04fF
C3523 a_5456_15242.n24 GND 0.00fF
C3524 a_5456_15242.n25 GND 0.00fF
C3525 a_5456_15242.t1 GND 0.02fF $ **FLOATING
C3526 a_5456_15242.n26 GND 0.07fF
C3527 a_5456_15242.n27 GND 0.02fF
C3528 a_5456_15242.n28 GND 0.05fF
C3529 a_5456_15242.n30 GND 0.01fF
C3530 a_5456_15242.n31 GND 0.00fF
C3531 a_5456_15242.n32 GND 0.01fF
C3532 a_5456_15242.n33 GND 0.00fF
C3533 a_5456_15242.n34 GND 0.00fF
C3534 a_5456_15242.n35 GND 0.00fF
C3535 a_5456_15242.n36 GND 0.00fF
C3536 a_5456_15242.n38 GND 0.08fF
C3537 a_5456_15242.t3 GND 4.25fF $ **FLOATING
C3538 a_5456_15242.n39 GND 0.62fF
C3539 a_5456_15242.t2 GND 0.26fF $ **FLOATING
C3540 a_23916_526.n0 GND 0.01fF
C3541 a_23916_526.n1 GND 0.01fF
C3542 a_23916_526.n2 GND 0.00fF
C3543 a_23916_526.n3 GND 0.00fF
C3544 a_23916_526.n4 GND 0.00fF
C3545 a_23916_526.n5 GND 0.00fF
C3546 a_23916_526.n6 GND 0.00fF
C3547 a_23916_526.n7 GND 0.00fF
C3548 a_23916_526.n8 GND 0.00fF
C3549 a_23916_526.n9 GND 0.00fF
C3550 a_23916_526.t3 GND 0.02fF $ **FLOATING
C3551 a_23916_526.t2 GND 0.02fF $ **FLOATING
C3552 a_23916_526.n10 GND 0.05fF
C3553 a_23916_526.n11 GND 0.00fF
C3554 a_23916_526.n12 GND 0.00fF
C3555 a_23916_526.n13 GND 0.02fF
C3556 a_23916_526.n14 GND 0.05fF
C3557 a_23916_526.n15 GND 0.13fF
C3558 a_23916_526.n16 GND 0.01fF
C3559 a_23916_526.n17 GND 0.12fF
C3560 a_23916_526.t0 GND 3.94fF $ **FLOATING
C3561 a_23916_526.n18 GND 0.53fF
C3562 a_23916_526.t1 GND 0.24fF $ **FLOATING
C3563 a_1416_11506.n0 GND 0.01fF
C3564 a_1416_11506.n1 GND 0.01fF
C3565 a_1416_11506.n2 GND 0.00fF
C3566 a_1416_11506.n3 GND 0.00fF
C3567 a_1416_11506.n4 GND 0.00fF
C3568 a_1416_11506.n5 GND 0.00fF
C3569 a_1416_11506.n6 GND 0.00fF
C3570 a_1416_11506.n7 GND 0.00fF
C3571 a_1416_11506.n8 GND 0.00fF
C3572 a_1416_11506.n9 GND 0.00fF
C3573 a_1416_11506.t2 GND 0.02fF $ **FLOATING
C3574 a_1416_11506.t3 GND 0.02fF $ **FLOATING
C3575 a_1416_11506.n10 GND 0.05fF
C3576 a_1416_11506.n11 GND 0.00fF
C3577 a_1416_11506.n12 GND 0.00fF
C3578 a_1416_11506.n13 GND 0.02fF
C3579 a_1416_11506.n14 GND 0.05fF
C3580 a_1416_11506.n15 GND 0.13fF
C3581 a_1416_11506.n16 GND 0.01fF
C3582 a_1416_11506.n17 GND 0.12fF
C3583 a_1416_11506.t1 GND 3.94fF $ **FLOATING
C3584 a_1416_11506.n18 GND 0.53fF
C3585 a_1416_11506.t0 GND 0.24fF $ **FLOATING
C3586 a_1706_11582.n0 GND 0.00fF
C3587 a_1706_11582.n1 GND 0.00fF
C3588 a_1706_11582.n2 GND 0.01fF
C3589 a_1706_11582.n3 GND 0.01fF
C3590 a_1706_11582.n4 GND 0.00fF
C3591 a_1706_11582.n5 GND 0.01fF
C3592 a_1706_11582.n6 GND 0.00fF
C3593 a_1706_11582.n7 GND 0.00fF
C3594 a_1706_11582.n8 GND 0.00fF
C3595 a_1706_11582.n9 GND 0.00fF
C3596 a_1706_11582.n10 GND 0.09fF
C3597 a_1706_11582.n11 GND 0.00fF
C3598 a_1706_11582.n12 GND 0.01fF
C3599 a_1706_11582.n13 GND 0.01fF
C3600 a_1706_11582.n14 GND 0.01fF
C3601 a_1706_11582.n15 GND 0.00fF
C3602 a_1706_11582.n16 GND 0.00fF
C3603 a_1706_11582.n17 GND 0.00fF
C3604 a_1706_11582.t1 GND 0.02fF $ **FLOATING
C3605 a_1706_11582.n18 GND 0.07fF
C3606 a_1706_11582.n19 GND 0.02fF
C3607 a_1706_11582.n20 GND 0.05fF
C3608 a_1706_11582.n22 GND 0.04fF
C3609 a_1706_11582.n23 GND 0.04fF
C3610 a_1706_11582.n24 GND 0.00fF
C3611 a_1706_11582.n25 GND 0.00fF
C3612 a_1706_11582.t0 GND 0.02fF $ **FLOATING
C3613 a_1706_11582.n26 GND 0.07fF
C3614 a_1706_11582.n27 GND 0.02fF
C3615 a_1706_11582.n28 GND 0.05fF
C3616 a_1706_11582.n30 GND 0.01fF
C3617 a_1706_11582.n31 GND 0.00fF
C3618 a_1706_11582.n32 GND 0.01fF
C3619 a_1706_11582.n33 GND 0.00fF
C3620 a_1706_11582.n34 GND 0.00fF
C3621 a_1706_11582.n35 GND 0.00fF
C3622 a_1706_11582.n36 GND 0.00fF
C3623 a_1706_11582.n38 GND 0.08fF
C3624 a_1706_11582.t3 GND 4.25fF $ **FLOATING
C3625 a_1706_11582.n39 GND 0.62fF
C3626 a_1706_11582.t2 GND 0.26fF $ **FLOATING
C3627 bit3.t13 GND 0.06fF $ **FLOATING
C3628 bit3.t6 GND 0.03fF $ **FLOATING
C3629 bit3.n0 GND 0.08fF
C3630 bit3.n1 GND 0.01fF
C3631 bit3.n2 GND 0.01fF
C3632 bit3.t0 GND 0.12fF $ **FLOATING
C3633 bit3.n3 GND 0.03fF
C3634 bit3.n4 GND 0.02fF
C3635 bit3.t11 GND 0.12fF $ **FLOATING
C3636 bit3.n5 GND 0.03fF
C3637 bit3.n6 GND 0.02fF
C3638 bit3.n7 GND 0.37fF
C3639 bit3.n8 GND 2.11fF
C3640 bit3.t5 GND 0.12fF $ **FLOATING
C3641 bit3.n9 GND 0.03fF
C3642 bit3.n10 GND 0.02fF
C3643 bit3.t9 GND 0.12fF $ **FLOATING
C3644 bit3.n11 GND 0.03fF
C3645 bit3.n12 GND 0.01fF
C3646 bit3.n13 GND 0.01fF
C3647 bit3.n14 GND 0.02fF
C3648 bit3.n15 GND 0.37fF
C3649 bit3.n16 GND 1.79fF
C3650 bit3.t4 GND 0.12fF $ **FLOATING
C3651 bit3.n17 GND 0.03fF
C3652 bit3.n18 GND 0.02fF
C3653 bit3.t17 GND 0.12fF $ **FLOATING
C3654 bit3.n19 GND 0.03fF
C3655 bit3.n20 GND 0.01fF
C3656 bit3.n21 GND 0.01fF
C3657 bit3.n22 GND 0.02fF
C3658 bit3.n23 GND 0.37fF
C3659 bit3.n24 GND 1.79fF
C3660 bit3.t12 GND 0.12fF $ **FLOATING
C3661 bit3.n25 GND 0.03fF
C3662 bit3.n26 GND 0.02fF
C3663 bit3.t1 GND 0.12fF $ **FLOATING
C3664 bit3.n27 GND 0.03fF
C3665 bit3.n28 GND 0.01fF
C3666 bit3.n29 GND 0.01fF
C3667 bit3.n30 GND 0.02fF
C3668 bit3.n31 GND 0.37fF
C3669 bit3.n32 GND 1.79fF
C3670 bit3.t15 GND 0.12fF $ **FLOATING
C3671 bit3.n33 GND 0.03fF
C3672 bit3.n34 GND 0.02fF
C3673 bit3.t7 GND 0.12fF $ **FLOATING
C3674 bit3.n35 GND 0.03fF
C3675 bit3.n36 GND 0.01fF
C3676 bit3.n37 GND 0.01fF
C3677 bit3.n38 GND 0.02fF
C3678 bit3.n39 GND 0.37fF
C3679 bit3.n40 GND 1.79fF
C3680 bit3.t10 GND 0.12fF $ **FLOATING
C3681 bit3.n41 GND 0.03fF
C3682 bit3.n42 GND 0.02fF
C3683 bit3.t14 GND 0.12fF $ **FLOATING
C3684 bit3.n43 GND 0.03fF
C3685 bit3.n44 GND 0.01fF
C3686 bit3.n45 GND 0.01fF
C3687 bit3.n46 GND 0.02fF
C3688 bit3.n47 GND 0.37fF
C3689 bit3.n48 GND 1.79fF
C3690 bit3.t8 GND 0.12fF $ **FLOATING
C3691 bit3.n49 GND 0.03fF
C3692 bit3.n50 GND 0.02fF
C3693 bit3.t3 GND 0.12fF $ **FLOATING
C3694 bit3.n51 GND 0.03fF
C3695 bit3.n52 GND 0.01fF
C3696 bit3.n53 GND 0.01fF
C3697 bit3.n54 GND 0.02fF
C3698 bit3.n55 GND 0.37fF
C3699 bit3.n56 GND 1.79fF
C3700 bit3.t16 GND 0.12fF $ **FLOATING
C3701 bit3.n57 GND 0.03fF
C3702 bit3.n58 GND 0.02fF
C3703 bit3.t2 GND 0.12fF $ **FLOATING
C3704 bit3.n59 GND 0.03fF
C3705 bit3.n60 GND 0.01fF
C3706 bit3.n61 GND 0.01fF
C3707 bit3.n62 GND 0.02fF
C3708 bit3.n63 GND 0.37fF
C3709 bit3.n64 GND 1.48fF
C3710 a_23916_7846.n0 GND 0.01fF
C3711 a_23916_7846.n1 GND 0.01fF
C3712 a_23916_7846.n2 GND 0.00fF
C3713 a_23916_7846.n3 GND 0.00fF
C3714 a_23916_7846.n4 GND 0.00fF
C3715 a_23916_7846.n5 GND 0.00fF
C3716 a_23916_7846.n6 GND 0.00fF
C3717 a_23916_7846.n7 GND 0.00fF
C3718 a_23916_7846.n8 GND 0.00fF
C3719 a_23916_7846.n9 GND 0.00fF
C3720 a_23916_7846.t2 GND 0.02fF $ **FLOATING
C3721 a_23916_7846.t3 GND 0.02fF $ **FLOATING
C3722 a_23916_7846.n10 GND 0.05fF
C3723 a_23916_7846.n11 GND 0.00fF
C3724 a_23916_7846.n12 GND 0.00fF
C3725 a_23916_7846.n13 GND 0.02fF
C3726 a_23916_7846.n14 GND 0.05fF
C3727 a_23916_7846.n15 GND 0.13fF
C3728 a_23916_7846.n16 GND 0.01fF
C3729 a_23916_7846.n17 GND 0.12fF
C3730 a_23916_7846.t0 GND 3.94fF $ **FLOATING
C3731 a_23916_7846.n18 GND 0.53fF
C3732 a_23916_7846.t1 GND 0.24fF $ **FLOATING
C3733 a_24206_7922.n0 GND 0.00fF
C3734 a_24206_7922.n1 GND 0.00fF
C3735 a_24206_7922.n2 GND 0.01fF
C3736 a_24206_7922.n3 GND 0.01fF
C3737 a_24206_7922.n4 GND 0.00fF
C3738 a_24206_7922.n5 GND 0.01fF
C3739 a_24206_7922.n6 GND 0.00fF
C3740 a_24206_7922.n7 GND 0.00fF
C3741 a_24206_7922.n8 GND 0.00fF
C3742 a_24206_7922.n9 GND 0.00fF
C3743 a_24206_7922.n10 GND 0.09fF
C3744 a_24206_7922.n11 GND 0.00fF
C3745 a_24206_7922.n12 GND 0.01fF
C3746 a_24206_7922.n13 GND 0.01fF
C3747 a_24206_7922.n14 GND 0.01fF
C3748 a_24206_7922.n15 GND 0.00fF
C3749 a_24206_7922.n16 GND 0.00fF
C3750 a_24206_7922.n17 GND 0.00fF
C3751 a_24206_7922.t3 GND 0.02fF $ **FLOATING
C3752 a_24206_7922.n18 GND 0.07fF
C3753 a_24206_7922.n19 GND 0.02fF
C3754 a_24206_7922.n20 GND 0.05fF
C3755 a_24206_7922.n22 GND 0.04fF
C3756 a_24206_7922.n23 GND 0.04fF
C3757 a_24206_7922.n24 GND 0.00fF
C3758 a_24206_7922.n25 GND 0.00fF
C3759 a_24206_7922.t2 GND 0.02fF $ **FLOATING
C3760 a_24206_7922.n26 GND 0.07fF
C3761 a_24206_7922.n27 GND 0.02fF
C3762 a_24206_7922.n28 GND 0.05fF
C3763 a_24206_7922.n30 GND 0.01fF
C3764 a_24206_7922.n31 GND 0.00fF
C3765 a_24206_7922.n32 GND 0.01fF
C3766 a_24206_7922.n33 GND 0.00fF
C3767 a_24206_7922.n34 GND 0.00fF
C3768 a_24206_7922.n35 GND 0.00fF
C3769 a_24206_7922.n36 GND 0.00fF
C3770 a_24206_7922.n38 GND 0.08fF
C3771 a_24206_7922.t1 GND 4.25fF $ **FLOATING
C3772 a_24206_7922.n39 GND 0.62fF
C3773 a_24206_7922.t0 GND 0.26fF $ **FLOATING
C3774 a_1706_7922.n0 GND 0.00fF
C3775 a_1706_7922.n1 GND 0.00fF
C3776 a_1706_7922.n2 GND 0.01fF
C3777 a_1706_7922.n3 GND 0.01fF
C3778 a_1706_7922.n4 GND 0.00fF
C3779 a_1706_7922.n5 GND 0.01fF
C3780 a_1706_7922.n6 GND 0.00fF
C3781 a_1706_7922.n7 GND 0.00fF
C3782 a_1706_7922.n8 GND 0.00fF
C3783 a_1706_7922.n9 GND 0.00fF
C3784 a_1706_7922.n10 GND 0.09fF
C3785 a_1706_7922.n11 GND 0.00fF
C3786 a_1706_7922.n12 GND 0.01fF
C3787 a_1706_7922.n13 GND 0.01fF
C3788 a_1706_7922.n14 GND 0.01fF
C3789 a_1706_7922.n15 GND 0.00fF
C3790 a_1706_7922.n16 GND 0.00fF
C3791 a_1706_7922.n17 GND 0.00fF
C3792 a_1706_7922.t2 GND 0.02fF $ **FLOATING
C3793 a_1706_7922.n18 GND 0.07fF
C3794 a_1706_7922.n19 GND 0.02fF
C3795 a_1706_7922.n20 GND 0.05fF
C3796 a_1706_7922.n22 GND 0.04fF
C3797 a_1706_7922.n23 GND 0.04fF
C3798 a_1706_7922.n24 GND 0.00fF
C3799 a_1706_7922.n25 GND 0.00fF
C3800 a_1706_7922.t3 GND 0.02fF $ **FLOATING
C3801 a_1706_7922.n26 GND 0.07fF
C3802 a_1706_7922.n27 GND 0.02fF
C3803 a_1706_7922.n28 GND 0.05fF
C3804 a_1706_7922.n30 GND 0.01fF
C3805 a_1706_7922.n31 GND 0.00fF
C3806 a_1706_7922.n32 GND 0.01fF
C3807 a_1706_7922.n33 GND 0.00fF
C3808 a_1706_7922.n34 GND 0.00fF
C3809 a_1706_7922.n35 GND 0.00fF
C3810 a_1706_7922.n36 GND 0.00fF
C3811 a_1706_7922.n38 GND 0.08fF
C3812 a_1706_7922.t1 GND 4.25fF $ **FLOATING
C3813 a_1706_7922.n39 GND 0.62fF
C3814 a_1706_7922.t0 GND 0.26fF $ **FLOATING
C3815 a_1416_7846.n0 GND 0.01fF
C3816 a_1416_7846.n1 GND 0.01fF
C3817 a_1416_7846.n2 GND 0.00fF
C3818 a_1416_7846.n3 GND 0.00fF
C3819 a_1416_7846.n4 GND 0.00fF
C3820 a_1416_7846.n5 GND 0.00fF
C3821 a_1416_7846.n6 GND 0.00fF
C3822 a_1416_7846.n7 GND 0.00fF
C3823 a_1416_7846.n8 GND 0.00fF
C3824 a_1416_7846.n9 GND 0.00fF
C3825 a_1416_7846.t3 GND 0.02fF $ **FLOATING
C3826 a_1416_7846.t2 GND 0.02fF $ **FLOATING
C3827 a_1416_7846.n10 GND 0.05fF
C3828 a_1416_7846.n11 GND 0.00fF
C3829 a_1416_7846.n12 GND 0.00fF
C3830 a_1416_7846.n13 GND 0.02fF
C3831 a_1416_7846.n14 GND 0.05fF
C3832 a_1416_7846.n15 GND 0.13fF
C3833 a_1416_7846.n16 GND 0.01fF
C3834 a_1416_7846.n17 GND 0.12fF
C3835 a_1416_7846.t1 GND 3.94fF $ **FLOATING
C3836 a_1416_7846.n18 GND 0.53fF
C3837 a_1416_7846.t0 GND 0.24fF $ **FLOATING
C3838 bit4.t8 GND 0.07fF $ **FLOATING
C3839 bit4.t19 GND 0.03fF $ **FLOATING
C3840 bit4.n0 GND 0.07fF
C3841 bit4.t10 GND 0.13fF $ **FLOATING
C3842 bit4.n1 GND 0.03fF
C3843 bit4.n2 GND 0.02fF
C3844 bit4.t13 GND 0.13fF $ **FLOATING
C3845 bit4.n3 GND 0.03fF
C3846 bit4.n4 GND 0.01fF
C3847 bit4.n5 GND 0.01fF
C3848 bit4.n6 GND 0.02fF
C3849 bit4.n7 GND 0.60fF
C3850 bit4.t23 GND 0.13fF $ **FLOATING
C3851 bit4.n8 GND 0.03fF
C3852 bit4.n9 GND 0.02fF
C3853 bit4.t16 GND 0.13fF $ **FLOATING
C3854 bit4.n10 GND 0.03fF
C3855 bit4.n11 GND 0.01fF
C3856 bit4.n12 GND 0.01fF
C3857 bit4.n13 GND 0.02fF
C3858 bit4.n14 GND 0.38fF
C3859 bit4.n15 GND 1.86fF
C3860 bit4.t27 GND 0.13fF $ **FLOATING
C3861 bit4.n16 GND 0.03fF
C3862 bit4.n17 GND 0.02fF
C3863 bit4.t32 GND 0.13fF $ **FLOATING
C3864 bit4.n18 GND 0.03fF
C3865 bit4.n19 GND 0.01fF
C3866 bit4.n20 GND 0.01fF
C3867 bit4.n21 GND 0.02fF
C3868 bit4.n22 GND 0.38fF
C3869 bit4.n23 GND 1.85fF
C3870 bit4.t11 GND 0.13fF $ **FLOATING
C3871 bit4.n24 GND 0.03fF
C3872 bit4.n25 GND 0.02fF
C3873 bit4.t2 GND 0.13fF $ **FLOATING
C3874 bit4.n26 GND 0.03fF
C3875 bit4.n27 GND 0.01fF
C3876 bit4.n28 GND 0.01fF
C3877 bit4.n29 GND 0.02fF
C3878 bit4.n30 GND 0.38fF
C3879 bit4.n31 GND 1.85fF
C3880 bit4.t26 GND 0.13fF $ **FLOATING
C3881 bit4.n32 GND 0.03fF
C3882 bit4.n33 GND 0.02fF
C3883 bit4.t28 GND 0.13fF $ **FLOATING
C3884 bit4.n34 GND 0.03fF
C3885 bit4.n35 GND 0.01fF
C3886 bit4.n36 GND 0.01fF
C3887 bit4.n37 GND 0.02fF
C3888 bit4.n38 GND 0.38fF
C3889 bit4.n39 GND 1.85fF
C3890 bit4.t12 GND 0.13fF $ **FLOATING
C3891 bit4.n40 GND 0.03fF
C3892 bit4.n41 GND 0.02fF
C3893 bit4.t4 GND 0.13fF $ **FLOATING
C3894 bit4.n42 GND 0.03fF
C3895 bit4.n43 GND 0.01fF
C3896 bit4.n44 GND 0.01fF
C3897 bit4.n45 GND 0.02fF
C3898 bit4.n46 GND 0.38fF
C3899 bit4.n47 GND 1.85fF
C3900 bit4.t14 GND 0.13fF $ **FLOATING
C3901 bit4.n48 GND 0.03fF
C3902 bit4.n49 GND 0.02fF
C3903 bit4.t18 GND 0.13fF $ **FLOATING
C3904 bit4.n50 GND 0.03fF
C3905 bit4.n51 GND 0.01fF
C3906 bit4.n52 GND 0.01fF
C3907 bit4.n53 GND 0.02fF
C3908 bit4.n54 GND 0.38fF
C3909 bit4.n55 GND 1.85fF
C3910 bit4.n56 GND 0.01fF
C3911 bit4.n57 GND 0.01fF
C3912 bit4.t30 GND 0.13fF $ **FLOATING
C3913 bit4.n58 GND 0.03fF
C3914 bit4.n59 GND 0.02fF
C3915 bit4.t21 GND 0.13fF $ **FLOATING
C3916 bit4.n60 GND 0.03fF
C3917 bit4.n61 GND 0.02fF
C3918 bit4.n62 GND 0.38fF
C3919 bit4.n63 GND 1.79fF
C3920 bit4.n64 GND 1.39fF
C3921 bit4.t7 GND 0.13fF $ **FLOATING
C3922 bit4.n65 GND 0.03fF
C3923 bit4.n66 GND 0.02fF
C3924 bit4.t0 GND 0.13fF $ **FLOATING
C3925 bit4.n67 GND 0.03fF
C3926 bit4.n68 GND 0.01fF
C3927 bit4.n69 GND 0.01fF
C3928 bit4.n70 GND 0.02fF
C3929 bit4.n71 GND 0.38fF
C3930 bit4.n72 GND 1.54fF
C3931 bit4.t29 GND 0.13fF $ **FLOATING
C3932 bit4.n73 GND 0.03fF
C3933 bit4.n74 GND 0.02fF
C3934 bit4.t33 GND 0.13fF $ **FLOATING
C3935 bit4.n75 GND 0.03fF
C3936 bit4.n76 GND 0.01fF
C3937 bit4.n77 GND 0.01fF
C3938 bit4.n78 GND 0.02fF
C3939 bit4.n79 GND 0.38fF
C3940 bit4.n80 GND 1.85fF
C3941 bit4.t24 GND 0.13fF $ **FLOATING
C3942 bit4.n81 GND 0.03fF
C3943 bit4.n82 GND 0.02fF
C3944 bit4.t17 GND 0.13fF $ **FLOATING
C3945 bit4.n83 GND 0.03fF
C3946 bit4.n84 GND 0.01fF
C3947 bit4.n85 GND 0.01fF
C3948 bit4.n86 GND 0.02fF
C3949 bit4.n87 GND 0.38fF
C3950 bit4.n88 GND 1.85fF
C3951 bit4.t3 GND 0.13fF $ **FLOATING
C3952 bit4.n89 GND 0.03fF
C3953 bit4.n90 GND 0.02fF
C3954 bit4.t6 GND 0.13fF $ **FLOATING
C3955 bit4.n91 GND 0.03fF
C3956 bit4.n92 GND 0.01fF
C3957 bit4.n93 GND 0.01fF
C3958 bit4.n94 GND 0.02fF
C3959 bit4.n95 GND 0.38fF
C3960 bit4.n96 GND 1.85fF
C3961 bit4.t22 GND 0.13fF $ **FLOATING
C3962 bit4.n97 GND 0.03fF
C3963 bit4.n98 GND 0.02fF
C3964 bit4.t15 GND 0.13fF $ **FLOATING
C3965 bit4.n99 GND 0.03fF
C3966 bit4.n100 GND 0.01fF
C3967 bit4.n101 GND 0.01fF
C3968 bit4.n102 GND 0.02fF
C3969 bit4.n103 GND 0.38fF
C3970 bit4.n104 GND 1.85fF
C3971 bit4.t5 GND 0.13fF $ **FLOATING
C3972 bit4.n105 GND 0.03fF
C3973 bit4.n106 GND 0.02fF
C3974 bit4.t9 GND 0.13fF $ **FLOATING
C3975 bit4.n107 GND 0.03fF
C3976 bit4.n108 GND 0.01fF
C3977 bit4.n109 GND 0.01fF
C3978 bit4.n110 GND 0.02fF
C3979 bit4.n111 GND 0.38fF
C3980 bit4.n112 GND 1.85fF
C3981 bit4.t1 GND 0.13fF $ **FLOATING
C3982 bit4.n113 GND 0.03fF
C3983 bit4.n114 GND 0.02fF
C3984 bit4.t31 GND 0.13fF $ **FLOATING
C3985 bit4.n115 GND 0.03fF
C3986 bit4.n116 GND 0.01fF
C3987 bit4.n117 GND 0.01fF
C3988 bit4.n118 GND 0.02fF
C3989 bit4.n119 GND 0.38fF
C3990 bit4.n120 GND 1.85fF
C3991 bit4.t20 GND 0.13fF $ **FLOATING
C3992 bit4.n121 GND 0.03fF
C3993 bit4.n122 GND 0.02fF
C3994 bit4.t25 GND 0.13fF $ **FLOATING
C3995 bit4.n123 GND 0.03fF
C3996 bit4.n124 GND 0.01fF
C3997 bit4.n125 GND 0.01fF
C3998 bit4.n126 GND 0.02fF
C3999 bit4.n127 GND 0.38fF
C4000 bit4.n128 GND 1.53fF
C4001 a_20456_4262.n0 GND 0.00fF
C4002 a_20456_4262.n1 GND 0.00fF
C4003 a_20456_4262.n2 GND 0.01fF
C4004 a_20456_4262.n3 GND 0.01fF
C4005 a_20456_4262.n4 GND 0.00fF
C4006 a_20456_4262.n5 GND 0.01fF
C4007 a_20456_4262.n6 GND 0.00fF
C4008 a_20456_4262.n7 GND 0.00fF
C4009 a_20456_4262.n8 GND 0.00fF
C4010 a_20456_4262.n9 GND 0.00fF
C4011 a_20456_4262.n10 GND 0.09fF
C4012 a_20456_4262.n11 GND 0.00fF
C4013 a_20456_4262.n12 GND 0.01fF
C4014 a_20456_4262.n13 GND 0.01fF
C4015 a_20456_4262.n14 GND 0.01fF
C4016 a_20456_4262.n15 GND 0.00fF
C4017 a_20456_4262.n16 GND 0.00fF
C4018 a_20456_4262.n17 GND 0.00fF
C4019 a_20456_4262.t2 GND 0.02fF $ **FLOATING
C4020 a_20456_4262.n18 GND 0.07fF
C4021 a_20456_4262.n19 GND 0.02fF
C4022 a_20456_4262.n20 GND 0.05fF
C4023 a_20456_4262.n22 GND 0.04fF
C4024 a_20456_4262.n23 GND 0.04fF
C4025 a_20456_4262.n24 GND 0.00fF
C4026 a_20456_4262.n25 GND 0.00fF
C4027 a_20456_4262.t1 GND 0.02fF $ **FLOATING
C4028 a_20456_4262.n26 GND 0.07fF
C4029 a_20456_4262.n27 GND 0.02fF
C4030 a_20456_4262.n28 GND 0.05fF
C4031 a_20456_4262.n30 GND 0.01fF
C4032 a_20456_4262.n31 GND 0.00fF
C4033 a_20456_4262.n32 GND 0.01fF
C4034 a_20456_4262.n33 GND 0.00fF
C4035 a_20456_4262.n34 GND 0.00fF
C4036 a_20456_4262.n35 GND 0.00fF
C4037 a_20456_4262.n36 GND 0.00fF
C4038 a_20456_4262.n38 GND 0.08fF
C4039 a_20456_4262.t3 GND 4.25fF $ **FLOATING
C4040 a_20456_4262.n39 GND 0.62fF
C4041 a_20456_4262.t0 GND 0.26fF $ **FLOATING
C4042 a_1416_13336.n0 GND 0.01fF
C4043 a_1416_13336.n1 GND 0.01fF
C4044 a_1416_13336.n2 GND 0.00fF
C4045 a_1416_13336.n3 GND 0.00fF
C4046 a_1416_13336.n4 GND 0.00fF
C4047 a_1416_13336.n5 GND 0.00fF
C4048 a_1416_13336.n6 GND 0.00fF
C4049 a_1416_13336.n7 GND 0.00fF
C4050 a_1416_13336.n8 GND 0.00fF
C4051 a_1416_13336.n9 GND 0.00fF
C4052 a_1416_13336.t2 GND 0.02fF $ **FLOATING
C4053 a_1416_13336.t1 GND 0.02fF $ **FLOATING
C4054 a_1416_13336.n10 GND 0.05fF
C4055 a_1416_13336.n11 GND 0.00fF
C4056 a_1416_13336.n12 GND 0.00fF
C4057 a_1416_13336.n13 GND 0.02fF
C4058 a_1416_13336.n14 GND 0.05fF
C4059 a_1416_13336.n15 GND 0.13fF
C4060 a_1416_13336.n16 GND 0.01fF
C4061 a_1416_13336.n17 GND 0.12fF
C4062 a_1416_13336.t0 GND 3.94fF $ **FLOATING
C4063 a_1416_13336.n18 GND 0.53fF
C4064 a_1416_13336.t3 GND 0.24fF $ **FLOATING
C4065 a_n456_7326.t1 GND 0.13fF $ **FLOATING
C4066 a_n456_7326.t15 GND 0.23fF $ **FLOATING
C4067 a_n456_7326.t11 GND 0.23fF $ **FLOATING
C4068 a_n456_7326.t14 GND 0.23fF $ **FLOATING
C4069 a_n456_7326.t20 GND 0.23fF $ **FLOATING
C4070 a_n456_7326.t25 GND 0.23fF $ **FLOATING
C4071 a_n456_7326.t19 GND 0.23fF $ **FLOATING
C4072 a_n456_7326.t31 GND 0.23fF $ **FLOATING
C4073 a_n456_7326.t6 GND 0.23fF $ **FLOATING
C4074 a_n456_7326.t10 GND 0.23fF $ **FLOATING
C4075 a_n456_7326.t5 GND 0.23fF $ **FLOATING
C4076 a_n456_7326.t18 GND 0.23fF $ **FLOATING
C4077 a_n456_7326.t2 GND 0.23fF $ **FLOATING
C4078 a_n456_7326.t4 GND 0.23fF $ **FLOATING
C4079 a_n456_7326.t30 GND 0.23fF $ **FLOATING
C4080 a_n456_7326.t3 GND 0.23fF $ **FLOATING
C4081 a_n456_7326.t9 GND 0.30fF $ **FLOATING
C4082 a_n456_7326.n0 GND 2.31fF
C4083 a_n456_7326.n1 GND 1.18fF
C4084 a_n456_7326.n2 GND 1.18fF
C4085 a_n456_7326.n3 GND 1.18fF
C4086 a_n456_7326.n4 GND 1.18fF
C4087 a_n456_7326.n5 GND 1.18fF
C4088 a_n456_7326.n6 GND 1.18fF
C4089 a_n456_7326.n7 GND 1.18fF
C4090 a_n456_7326.n8 GND 1.18fF
C4091 a_n456_7326.n9 GND 1.18fF
C4092 a_n456_7326.n10 GND 1.18fF
C4093 a_n456_7326.n11 GND 1.18fF
C4094 a_n456_7326.n12 GND 1.18fF
C4095 a_n456_7326.n13 GND 1.18fF
C4096 a_n456_7326.n14 GND 1.45fF
C4097 a_n456_7326.t13 GND 0.23fF $ **FLOATING
C4098 a_n456_7326.t12 GND 0.23fF $ **FLOATING
C4099 a_n456_7326.t8 GND 0.23fF $ **FLOATING
C4100 a_n456_7326.t23 GND 0.23fF $ **FLOATING
C4101 a_n456_7326.t32 GND 0.23fF $ **FLOATING
C4102 a_n456_7326.t17 GND 0.23fF $ **FLOATING
C4103 a_n456_7326.t7 GND 0.23fF $ **FLOATING
C4104 a_n456_7326.t28 GND 0.23fF $ **FLOATING
C4105 a_n456_7326.t26 GND 0.23fF $ **FLOATING
C4106 a_n456_7326.t33 GND 0.23fF $ **FLOATING
C4107 a_n456_7326.t22 GND 0.23fF $ **FLOATING
C4108 a_n456_7326.t29 GND 0.23fF $ **FLOATING
C4109 a_n456_7326.t27 GND 0.23fF $ **FLOATING
C4110 a_n456_7326.t24 GND 0.23fF $ **FLOATING
C4111 a_n456_7326.t21 GND 0.23fF $ **FLOATING
C4112 a_n456_7326.t16 GND 0.30fF $ **FLOATING
C4113 a_n456_7326.n15 GND 2.31fF
C4114 a_n456_7326.n16 GND 1.18fF
C4115 a_n456_7326.n17 GND 1.18fF
C4116 a_n456_7326.n18 GND 1.18fF
C4117 a_n456_7326.n19 GND 1.18fF
C4118 a_n456_7326.n20 GND 1.18fF
C4119 a_n456_7326.n21 GND 1.18fF
C4120 a_n456_7326.n22 GND 1.18fF
C4121 a_n456_7326.n23 GND 1.18fF
C4122 a_n456_7326.n24 GND 1.18fF
C4123 a_n456_7326.n25 GND 1.18fF
C4124 a_n456_7326.n26 GND 1.18fF
C4125 a_n456_7326.n27 GND 1.18fF
C4126 a_n456_7326.n28 GND 1.18fF
C4127 a_n456_7326.n29 GND 0.89fF
C4128 a_n456_7326.n30 GND 1.33fF
C4129 a_n456_7326.n31 GND 0.09fF
C4130 a_n456_7326.t0 GND 0.28fF $ **FLOATING
C4131 a_8916_7846.n0 GND 0.01fF
C4132 a_8916_7846.n1 GND 0.01fF
C4133 a_8916_7846.n2 GND 0.00fF
C4134 a_8916_7846.n3 GND 0.00fF
C4135 a_8916_7846.n4 GND 0.00fF
C4136 a_8916_7846.n5 GND 0.00fF
C4137 a_8916_7846.n6 GND 0.00fF
C4138 a_8916_7846.n7 GND 0.00fF
C4139 a_8916_7846.n8 GND 0.00fF
C4140 a_8916_7846.n9 GND 0.00fF
C4141 a_8916_7846.t0 GND 0.02fF $ **FLOATING
C4142 a_8916_7846.t1 GND 0.02fF $ **FLOATING
C4143 a_8916_7846.n10 GND 0.05fF
C4144 a_8916_7846.n11 GND 0.00fF
C4145 a_8916_7846.n12 GND 0.00fF
C4146 a_8916_7846.n13 GND 0.02fF
C4147 a_8916_7846.n14 GND 0.05fF
C4148 a_8916_7846.n15 GND 0.13fF
C4149 a_8916_7846.n16 GND 0.01fF
C4150 a_8916_7846.n17 GND 0.12fF
C4151 a_8916_7846.t2 GND 3.94fF $ **FLOATING
C4152 a_8916_7846.n18 GND 0.53fF
C4153 a_8916_7846.t3 GND 0.24fF $ **FLOATING
C4154 a_n456_6.t63 GND 0.14fF $ **FLOATING
C4155 a_n456_6.t26 GND 0.24fF $ **FLOATING
C4156 a_n456_6.t38 GND 0.24fF $ **FLOATING
C4157 a_n456_6.t0 GND 0.24fF $ **FLOATING
C4158 a_n456_6.t56 GND 0.24fF $ **FLOATING
C4159 a_n456_6.t9 GND 0.24fF $ **FLOATING
C4160 a_n456_6.t28 GND 0.24fF $ **FLOATING
C4161 a_n456_6.t55 GND 0.24fF $ **FLOATING
C4162 a_n456_6.t22 GND 0.24fF $ **FLOATING
C4163 a_n456_6.t60 GND 0.24fF $ **FLOATING
C4164 a_n456_6.t48 GND 0.24fF $ **FLOATING
C4165 a_n456_6.t59 GND 0.24fF $ **FLOATING
C4166 a_n456_6.t29 GND 0.24fF $ **FLOATING
C4167 a_n456_6.t42 GND 0.24fF $ **FLOATING
C4168 a_n456_6.t4 GND 0.24fF $ **FLOATING
C4169 a_n456_6.t30 GND 0.24fF $ **FLOATING
C4170 a_n456_6.t2 GND 0.31fF $ **FLOATING
C4171 a_n456_6.n0 GND 2.44fF
C4172 a_n456_6.n1 GND 1.25fF
C4173 a_n456_6.n2 GND 1.25fF
C4174 a_n456_6.n3 GND 1.25fF
C4175 a_n456_6.n4 GND 1.25fF
C4176 a_n456_6.n5 GND 1.25fF
C4177 a_n456_6.n6 GND 1.25fF
C4178 a_n456_6.n7 GND 1.25fF
C4179 a_n456_6.n8 GND 1.25fF
C4180 a_n456_6.n9 GND 1.25fF
C4181 a_n456_6.n10 GND 1.25fF
C4182 a_n456_6.n11 GND 1.25fF
C4183 a_n456_6.n12 GND 1.25fF
C4184 a_n456_6.n13 GND 1.25fF
C4185 a_n456_6.n14 GND 0.94fF
C4186 a_n456_6.t54 GND 0.24fF $ **FLOATING
C4187 a_n456_6.t34 GND 0.24fF $ **FLOATING
C4188 a_n456_6.t62 GND 0.24fF $ **FLOATING
C4189 a_n456_6.t52 GND 0.24fF $ **FLOATING
C4190 a_n456_6.t46 GND 0.24fF $ **FLOATING
C4191 a_n456_6.t44 GND 0.24fF $ **FLOATING
C4192 a_n456_6.t35 GND 0.24fF $ **FLOATING
C4193 a_n456_6.t21 GND 0.24fF $ **FLOATING
C4194 a_n456_6.t15 GND 0.24fF $ **FLOATING
C4195 a_n456_6.t10 GND 0.24fF $ **FLOATING
C4196 a_n456_6.t50 GND 0.24fF $ **FLOATING
C4197 a_n456_6.t24 GND 0.24fF $ **FLOATING
C4198 a_n456_6.t18 GND 0.24fF $ **FLOATING
C4199 a_n456_6.t13 GND 0.24fF $ **FLOATING
C4200 a_n456_6.t6 GND 0.24fF $ **FLOATING
C4201 a_n456_6.t41 GND 0.31fF $ **FLOATING
C4202 a_n456_6.n15 GND 2.44fF
C4203 a_n456_6.n16 GND 1.25fF
C4204 a_n456_6.n17 GND 1.25fF
C4205 a_n456_6.n18 GND 1.25fF
C4206 a_n456_6.n19 GND 1.25fF
C4207 a_n456_6.n20 GND 1.25fF
C4208 a_n456_6.n21 GND 1.25fF
C4209 a_n456_6.n22 GND 1.25fF
C4210 a_n456_6.n23 GND 1.25fF
C4211 a_n456_6.n24 GND 1.25fF
C4212 a_n456_6.n25 GND 1.25fF
C4213 a_n456_6.n26 GND 1.25fF
C4214 a_n456_6.n27 GND 1.25fF
C4215 a_n456_6.n28 GND 1.25fF
C4216 a_n456_6.n29 GND 1.56fF
C4217 a_n456_6.t7 GND 0.24fF $ **FLOATING
C4218 a_n456_6.t3 GND 0.24fF $ **FLOATING
C4219 a_n456_6.t1 GND 0.24fF $ **FLOATING
C4220 a_n456_6.t27 GND 0.24fF $ **FLOATING
C4221 a_n456_6.t20 GND 0.24fF $ **FLOATING
C4222 a_n456_6.t17 GND 0.24fF $ **FLOATING
C4223 a_n456_6.t49 GND 0.24fF $ **FLOATING
C4224 a_n456_6.t58 GND 0.24fF $ **FLOATING
C4225 a_n456_6.t40 GND 0.24fF $ **FLOATING
C4226 a_n456_6.t65 GND 0.24fF $ **FLOATING
C4227 a_n456_6.t25 GND 0.24fF $ **FLOATING
C4228 a_n456_6.t32 GND 0.24fF $ **FLOATING
C4229 a_n456_6.t36 GND 0.24fF $ **FLOATING
C4230 a_n456_6.t61 GND 0.24fF $ **FLOATING
C4231 a_n456_6.t31 GND 0.24fF $ **FLOATING
C4232 a_n456_6.t12 GND 0.31fF $ **FLOATING
C4233 a_n456_6.n30 GND 2.44fF
C4234 a_n456_6.n31 GND 1.25fF
C4235 a_n456_6.n32 GND 1.25fF
C4236 a_n456_6.n33 GND 1.25fF
C4237 a_n456_6.n34 GND 1.25fF
C4238 a_n456_6.n35 GND 1.25fF
C4239 a_n456_6.n36 GND 1.25fF
C4240 a_n456_6.n37 GND 1.25fF
C4241 a_n456_6.n38 GND 1.25fF
C4242 a_n456_6.n39 GND 1.25fF
C4243 a_n456_6.n40 GND 1.25fF
C4244 a_n456_6.n41 GND 1.25fF
C4245 a_n456_6.n42 GND 1.25fF
C4246 a_n456_6.n43 GND 1.25fF
C4247 a_n456_6.n44 GND 0.94fF
C4248 a_n456_6.n45 GND 1.12fF
C4249 a_n456_6.t53 GND 0.24fF $ **FLOATING
C4250 a_n456_6.t33 GND 0.24fF $ **FLOATING
C4251 a_n456_6.t37 GND 0.24fF $ **FLOATING
C4252 a_n456_6.t51 GND 0.24fF $ **FLOATING
C4253 a_n456_6.t45 GND 0.24fF $ **FLOATING
C4254 a_n456_6.t43 GND 0.24fF $ **FLOATING
C4255 a_n456_6.t39 GND 0.24fF $ **FLOATING
C4256 a_n456_6.t19 GND 0.24fF $ **FLOATING
C4257 a_n456_6.t14 GND 0.24fF $ **FLOATING
C4258 a_n456_6.t8 GND 0.24fF $ **FLOATING
C4259 a_n456_6.t47 GND 0.24fF $ **FLOATING
C4260 a_n456_6.t23 GND 0.24fF $ **FLOATING
C4261 a_n456_6.t16 GND 0.24fF $ **FLOATING
C4262 a_n456_6.t11 GND 0.24fF $ **FLOATING
C4263 a_n456_6.t5 GND 0.24fF $ **FLOATING
C4264 a_n456_6.t57 GND 0.31fF $ **FLOATING
C4265 a_n456_6.n46 GND 2.44fF
C4266 a_n456_6.n47 GND 1.25fF
C4267 a_n456_6.n48 GND 1.25fF
C4268 a_n456_6.n49 GND 1.25fF
C4269 a_n456_6.n50 GND 1.25fF
C4270 a_n456_6.n51 GND 1.25fF
C4271 a_n456_6.n52 GND 1.25fF
C4272 a_n456_6.n53 GND 1.25fF
C4273 a_n456_6.n54 GND 1.25fF
C4274 a_n456_6.n55 GND 1.25fF
C4275 a_n456_6.n56 GND 1.25fF
C4276 a_n456_6.n57 GND 1.25fF
C4277 a_n456_6.n58 GND 1.25fF
C4278 a_n456_6.n59 GND 1.25fF
C4279 a_n456_6.n60 GND 0.94fF
C4280 a_n456_6.n61 GND 0.93fF
C4281 a_n456_6.n62 GND 1.06fF
C4282 a_n456_6.n63 GND 0.10fF
C4283 a_n456_6.t64 GND 0.29fF $ **FLOATING
C4284 a_16706_4262.n0 GND 0.00fF
C4285 a_16706_4262.n1 GND 0.00fF
C4286 a_16706_4262.n2 GND 0.01fF
C4287 a_16706_4262.n3 GND 0.01fF
C4288 a_16706_4262.n4 GND 0.00fF
C4289 a_16706_4262.n5 GND 0.01fF
C4290 a_16706_4262.n6 GND 0.00fF
C4291 a_16706_4262.n7 GND 0.00fF
C4292 a_16706_4262.n8 GND 0.00fF
C4293 a_16706_4262.n9 GND 0.00fF
C4294 a_16706_4262.n10 GND 0.09fF
C4295 a_16706_4262.n11 GND 0.00fF
C4296 a_16706_4262.n12 GND 0.01fF
C4297 a_16706_4262.n13 GND 0.01fF
C4298 a_16706_4262.n14 GND 0.01fF
C4299 a_16706_4262.n15 GND 0.00fF
C4300 a_16706_4262.n16 GND 0.00fF
C4301 a_16706_4262.n17 GND 0.00fF
C4302 a_16706_4262.t1 GND 0.02fF $ **FLOATING
C4303 a_16706_4262.n18 GND 0.07fF
C4304 a_16706_4262.n19 GND 0.02fF
C4305 a_16706_4262.n20 GND 0.05fF
C4306 a_16706_4262.n22 GND 0.04fF
C4307 a_16706_4262.n23 GND 0.04fF
C4308 a_16706_4262.n24 GND 0.00fF
C4309 a_16706_4262.n25 GND 0.00fF
C4310 a_16706_4262.t0 GND 0.02fF $ **FLOATING
C4311 a_16706_4262.n26 GND 0.07fF
C4312 a_16706_4262.n27 GND 0.02fF
C4313 a_16706_4262.n28 GND 0.05fF
C4314 a_16706_4262.n30 GND 0.01fF
C4315 a_16706_4262.n31 GND 0.00fF
C4316 a_16706_4262.n32 GND 0.01fF
C4317 a_16706_4262.n33 GND 0.00fF
C4318 a_16706_4262.n34 GND 0.00fF
C4319 a_16706_4262.n35 GND 0.00fF
C4320 a_16706_4262.n36 GND 0.00fF
C4321 a_16706_4262.n38 GND 0.08fF
C4322 a_16706_4262.t2 GND 4.25fF $ **FLOATING
C4323 a_16706_4262.n39 GND 0.62fF
C4324 a_16706_4262.t3 GND 0.26fF $ **FLOATING
C4325 a_12666_6016.n0 GND 0.01fF
C4326 a_12666_6016.n1 GND 0.01fF
C4327 a_12666_6016.n2 GND 0.00fF
C4328 a_12666_6016.n3 GND 0.00fF
C4329 a_12666_6016.n4 GND 0.00fF
C4330 a_12666_6016.n5 GND 0.00fF
C4331 a_12666_6016.n6 GND 0.00fF
C4332 a_12666_6016.n7 GND 0.00fF
C4333 a_12666_6016.n8 GND 0.00fF
C4334 a_12666_6016.n9 GND 0.00fF
C4335 a_12666_6016.t2 GND 0.02fF $ **FLOATING
C4336 a_12666_6016.t3 GND 0.02fF $ **FLOATING
C4337 a_12666_6016.n10 GND 0.05fF
C4338 a_12666_6016.n11 GND 0.00fF
C4339 a_12666_6016.n12 GND 0.00fF
C4340 a_12666_6016.n13 GND 0.02fF
C4341 a_12666_6016.n14 GND 0.05fF
C4342 a_12666_6016.n15 GND 0.13fF
C4343 a_12666_6016.n16 GND 0.01fF
C4344 a_12666_6016.n17 GND 0.12fF
C4345 a_12666_6016.t0 GND 3.94fF $ **FLOATING
C4346 a_12666_6016.n18 GND 0.53fF
C4347 a_12666_6016.t1 GND 0.24fF $ **FLOATING
C4348 a_1416_9676.n0 GND 0.01fF
C4349 a_1416_9676.n1 GND 0.01fF
C4350 a_1416_9676.n2 GND 0.00fF
C4351 a_1416_9676.n3 GND 0.00fF
C4352 a_1416_9676.n4 GND 0.00fF
C4353 a_1416_9676.n5 GND 0.00fF
C4354 a_1416_9676.n6 GND 0.00fF
C4355 a_1416_9676.n7 GND 0.00fF
C4356 a_1416_9676.n8 GND 0.00fF
C4357 a_1416_9676.n9 GND 0.00fF
C4358 a_1416_9676.t0 GND 0.02fF $ **FLOATING
C4359 a_1416_9676.t1 GND 0.02fF $ **FLOATING
C4360 a_1416_9676.n10 GND 0.05fF
C4361 a_1416_9676.n11 GND 0.00fF
C4362 a_1416_9676.n12 GND 0.00fF
C4363 a_1416_9676.n13 GND 0.02fF
C4364 a_1416_9676.n14 GND 0.05fF
C4365 a_1416_9676.n15 GND 0.13fF
C4366 a_1416_9676.n16 GND 0.01fF
C4367 a_1416_9676.n17 GND 0.12fF
C4368 a_1416_9676.t3 GND 3.94fF $ **FLOATING
C4369 a_1416_9676.n18 GND 0.53fF
C4370 a_1416_9676.t2 GND 0.24fF $ **FLOATING
C4371 a_24206_602.n0 GND 0.00fF
C4372 a_24206_602.n1 GND 0.00fF
C4373 a_24206_602.n2 GND 0.01fF
C4374 a_24206_602.n3 GND 0.01fF
C4375 a_24206_602.n4 GND 0.00fF
C4376 a_24206_602.n5 GND 0.01fF
C4377 a_24206_602.n6 GND 0.00fF
C4378 a_24206_602.n7 GND 0.00fF
C4379 a_24206_602.n8 GND 0.00fF
C4380 a_24206_602.n9 GND 0.00fF
C4381 a_24206_602.n10 GND 0.09fF
C4382 a_24206_602.n11 GND 0.00fF
C4383 a_24206_602.n12 GND 0.01fF
C4384 a_24206_602.n13 GND 0.01fF
C4385 a_24206_602.n14 GND 0.01fF
C4386 a_24206_602.n15 GND 0.00fF
C4387 a_24206_602.n16 GND 0.00fF
C4388 a_24206_602.n17 GND 0.00fF
C4389 a_24206_602.t1 GND 0.02fF $ **FLOATING
C4390 a_24206_602.n18 GND 0.07fF
C4391 a_24206_602.n19 GND 0.02fF
C4392 a_24206_602.n20 GND 0.05fF
C4393 a_24206_602.n22 GND 0.04fF
C4394 a_24206_602.n23 GND 0.04fF
C4395 a_24206_602.n24 GND 0.00fF
C4396 a_24206_602.n25 GND 0.00fF
C4397 a_24206_602.t2 GND 0.02fF $ **FLOATING
C4398 a_24206_602.n26 GND 0.07fF
C4399 a_24206_602.n27 GND 0.02fF
C4400 a_24206_602.n28 GND 0.05fF
C4401 a_24206_602.n30 GND 0.01fF
C4402 a_24206_602.n31 GND 0.00fF
C4403 a_24206_602.n32 GND 0.01fF
C4404 a_24206_602.n33 GND 0.00fF
C4405 a_24206_602.n34 GND 0.00fF
C4406 a_24206_602.n35 GND 0.00fF
C4407 a_24206_602.n36 GND 0.00fF
C4408 a_24206_602.n38 GND 0.08fF
C4409 a_24206_602.t3 GND 4.25fF $ **FLOATING
C4410 a_24206_602.n39 GND 0.62fF
C4411 a_24206_602.t0 GND 0.26fF $ **FLOATING
C4412 a_n456_16476.t0 GND 0.15fF $ **FLOATING
C4413 a_n456_16476.t2 GND 0.26fF $ **FLOATING
C4414 a_n456_16476.t3 GND 0.34fF $ **FLOATING
C4415 a_n456_16476.n0 GND 3.34fF
C4416 a_n456_16476.n1 GND 0.13fF
C4417 a_n456_16476.t1 GND 0.32fF $ **FLOATING
C4418 a_1706_17072.n0 GND 0.00fF
C4419 a_1706_17072.n1 GND 0.00fF
C4420 a_1706_17072.n2 GND 0.01fF
C4421 a_1706_17072.n3 GND 0.01fF
C4422 a_1706_17072.n4 GND 0.00fF
C4423 a_1706_17072.n5 GND 0.01fF
C4424 a_1706_17072.n6 GND 0.00fF
C4425 a_1706_17072.n7 GND 0.00fF
C4426 a_1706_17072.n8 GND 0.00fF
C4427 a_1706_17072.n9 GND 0.00fF
C4428 a_1706_17072.n10 GND 0.09fF
C4429 a_1706_17072.n11 GND 0.00fF
C4430 a_1706_17072.n12 GND 0.01fF
C4431 a_1706_17072.n13 GND 0.01fF
C4432 a_1706_17072.n14 GND 0.01fF
C4433 a_1706_17072.n15 GND 0.00fF
C4434 a_1706_17072.n16 GND 0.00fF
C4435 a_1706_17072.n17 GND 0.00fF
C4436 a_1706_17072.t1 GND 0.02fF $ **FLOATING
C4437 a_1706_17072.n18 GND 0.07fF
C4438 a_1706_17072.n19 GND 0.02fF
C4439 a_1706_17072.n20 GND 0.05fF
C4440 a_1706_17072.n22 GND 0.04fF
C4441 a_1706_17072.n23 GND 0.04fF
C4442 a_1706_17072.n24 GND 0.00fF
C4443 a_1706_17072.n25 GND 0.00fF
C4444 a_1706_17072.t0 GND 0.02fF $ **FLOATING
C4445 a_1706_17072.n26 GND 0.07fF
C4446 a_1706_17072.n27 GND 0.02fF
C4447 a_1706_17072.n28 GND 0.05fF
C4448 a_1706_17072.n30 GND 0.01fF
C4449 a_1706_17072.n31 GND 0.00fF
C4450 a_1706_17072.n32 GND 0.01fF
C4451 a_1706_17072.n33 GND 0.00fF
C4452 a_1706_17072.n34 GND 0.00fF
C4453 a_1706_17072.n35 GND 0.00fF
C4454 a_1706_17072.n36 GND 0.00fF
C4455 a_1706_17072.n38 GND 0.08fF
C4456 a_1706_17072.t3 GND 4.25fF $ **FLOATING
C4457 a_1706_17072.n39 GND 0.62fF
C4458 a_1706_17072.t2 GND 0.26fF $ **FLOATING
C4459 a_n456_12816.t3 GND 0.14fF $ **FLOATING
C4460 a_n456_12816.t9 GND 0.24fF $ **FLOATING
C4461 a_n456_12816.t8 GND 0.24fF $ **FLOATING
C4462 a_n456_12816.t5 GND 0.24fF $ **FLOATING
C4463 a_n456_12816.t7 GND 0.24fF $ **FLOATING
C4464 a_n456_12816.t0 GND 0.24fF $ **FLOATING
C4465 a_n456_12816.t6 GND 0.24fF $ **FLOATING
C4466 a_n456_12816.t1 GND 0.24fF $ **FLOATING
C4467 a_n456_12816.t2 GND 0.31fF $ **FLOATING
C4468 a_n456_12816.n0 GND 2.42fF
C4469 a_n456_12816.n1 GND 1.24fF
C4470 a_n456_12816.n2 GND 1.24fF
C4471 a_n456_12816.n3 GND 1.24fF
C4472 a_n456_12816.n4 GND 1.24fF
C4473 a_n456_12816.n5 GND 1.24fF
C4474 a_n456_12816.n6 GND 1.83fF
C4475 a_n456_12816.n7 GND 0.12fF
C4476 a_n456_12816.t4 GND 0.29fF $ **FLOATING
C4477 a_1706_13412.n0 GND 0.00fF
C4478 a_1706_13412.n1 GND 0.00fF
C4479 a_1706_13412.n2 GND 0.01fF
C4480 a_1706_13412.n3 GND 0.01fF
C4481 a_1706_13412.n4 GND 0.00fF
C4482 a_1706_13412.n5 GND 0.01fF
C4483 a_1706_13412.n6 GND 0.00fF
C4484 a_1706_13412.n7 GND 0.00fF
C4485 a_1706_13412.n8 GND 0.00fF
C4486 a_1706_13412.n9 GND 0.00fF
C4487 a_1706_13412.n10 GND 0.09fF
C4488 a_1706_13412.n11 GND 0.00fF
C4489 a_1706_13412.n12 GND 0.01fF
C4490 a_1706_13412.n13 GND 0.01fF
C4491 a_1706_13412.n14 GND 0.01fF
C4492 a_1706_13412.n15 GND 0.00fF
C4493 a_1706_13412.n16 GND 0.00fF
C4494 a_1706_13412.n17 GND 0.00fF
C4495 a_1706_13412.t1 GND 0.02fF $ **FLOATING
C4496 a_1706_13412.n18 GND 0.07fF
C4497 a_1706_13412.n19 GND 0.02fF
C4498 a_1706_13412.n20 GND 0.05fF
C4499 a_1706_13412.n22 GND 0.04fF
C4500 a_1706_13412.n23 GND 0.04fF
C4501 a_1706_13412.n24 GND 0.00fF
C4502 a_1706_13412.n25 GND 0.00fF
C4503 a_1706_13412.t0 GND 0.02fF $ **FLOATING
C4504 a_1706_13412.n26 GND 0.07fF
C4505 a_1706_13412.n27 GND 0.02fF
C4506 a_1706_13412.n28 GND 0.05fF
C4507 a_1706_13412.n30 GND 0.01fF
C4508 a_1706_13412.n31 GND 0.00fF
C4509 a_1706_13412.n32 GND 0.01fF
C4510 a_1706_13412.n33 GND 0.00fF
C4511 a_1706_13412.n34 GND 0.00fF
C4512 a_1706_13412.n35 GND 0.00fF
C4513 a_1706_13412.n36 GND 0.00fF
C4514 a_1706_13412.n38 GND 0.08fF
C4515 a_1706_13412.t3 GND 4.25fF $ **FLOATING
C4516 a_1706_13412.n39 GND 0.62fF
C4517 a_1706_13412.t2 GND 0.26fF $ **FLOATING
C4518 a_12956_602.n0 GND 0.00fF
C4519 a_12956_602.n1 GND 0.00fF
C4520 a_12956_602.n2 GND 0.01fF
C4521 a_12956_602.n3 GND 0.01fF
C4522 a_12956_602.n4 GND 0.00fF
C4523 a_12956_602.n5 GND 0.01fF
C4524 a_12956_602.n6 GND 0.00fF
C4525 a_12956_602.n7 GND 0.00fF
C4526 a_12956_602.n8 GND 0.00fF
C4527 a_12956_602.n9 GND 0.00fF
C4528 a_12956_602.n10 GND 0.09fF
C4529 a_12956_602.n11 GND 0.00fF
C4530 a_12956_602.n12 GND 0.01fF
C4531 a_12956_602.n13 GND 0.01fF
C4532 a_12956_602.n14 GND 0.01fF
C4533 a_12956_602.n15 GND 0.00fF
C4534 a_12956_602.n16 GND 0.00fF
C4535 a_12956_602.n17 GND 0.00fF
C4536 a_12956_602.t1 GND 0.02fF $ **FLOATING
C4537 a_12956_602.n18 GND 0.07fF
C4538 a_12956_602.n19 GND 0.02fF
C4539 a_12956_602.n20 GND 0.05fF
C4540 a_12956_602.n22 GND 0.04fF
C4541 a_12956_602.n23 GND 0.04fF
C4542 a_12956_602.n24 GND 0.00fF
C4543 a_12956_602.n25 GND 0.00fF
C4544 a_12956_602.t2 GND 0.02fF $ **FLOATING
C4545 a_12956_602.n26 GND 0.07fF
C4546 a_12956_602.n27 GND 0.02fF
C4547 a_12956_602.n28 GND 0.05fF
C4548 a_12956_602.n30 GND 0.01fF
C4549 a_12956_602.n31 GND 0.00fF
C4550 a_12956_602.n32 GND 0.01fF
C4551 a_12956_602.n33 GND 0.00fF
C4552 a_12956_602.n34 GND 0.00fF
C4553 a_12956_602.n35 GND 0.00fF
C4554 a_12956_602.n36 GND 0.00fF
C4555 a_12956_602.n38 GND 0.08fF
C4556 a_12956_602.t3 GND 4.25fF $ **FLOATING
C4557 a_12956_602.n39 GND 0.62fF
C4558 a_12956_602.t0 GND 0.26fF $ **FLOATING
C4559 a_12666_526.n0 GND 0.01fF
C4560 a_12666_526.n1 GND 0.01fF
C4561 a_12666_526.n2 GND 0.00fF
C4562 a_12666_526.n3 GND 0.00fF
C4563 a_12666_526.n4 GND 0.00fF
C4564 a_12666_526.n5 GND 0.00fF
C4565 a_12666_526.n6 GND 0.00fF
C4566 a_12666_526.n7 GND 0.00fF
C4567 a_12666_526.n8 GND 0.00fF
C4568 a_12666_526.n9 GND 0.00fF
C4569 a_12666_526.t3 GND 0.02fF $ **FLOATING
C4570 a_12666_526.t2 GND 0.02fF $ **FLOATING
C4571 a_12666_526.n10 GND 0.05fF
C4572 a_12666_526.n11 GND 0.00fF
C4573 a_12666_526.n12 GND 0.00fF
C4574 a_12666_526.n13 GND 0.02fF
C4575 a_12666_526.n14 GND 0.05fF
C4576 a_12666_526.n15 GND 0.13fF
C4577 a_12666_526.n16 GND 0.01fF
C4578 a_12666_526.n17 GND 0.12fF
C4579 a_12666_526.t0 GND 3.94fF $ **FLOATING
C4580 a_12666_526.n18 GND 0.53fF
C4581 a_12666_526.t1 GND 0.24fF $ **FLOATING
C4582 bit5.t46 GND 0.07fF $ **FLOATING
C4583 bit5.t39 GND 0.03fF $ **FLOATING
C4584 bit5.n0 GND 0.07fF
C4585 bit5.t22 GND 0.14fF $ **FLOATING
C4586 bit5.n1 GND 0.03fF
C4587 bit5.n2 GND 0.02fF
C4588 bit5.t26 GND 0.14fF $ **FLOATING
C4589 bit5.n3 GND 0.04fF
C4590 bit5.n4 GND 0.02fF
C4591 bit5.n5 GND 0.01fF
C4592 bit5.n6 GND 0.02fF
C4593 bit5.n7 GND 0.64fF
C4594 bit5.t48 GND 0.14fF $ **FLOATING
C4595 bit5.n8 GND 0.03fF
C4596 bit5.n9 GND 0.02fF
C4597 bit5.t33 GND 0.14fF $ **FLOATING
C4598 bit5.n10 GND 0.04fF
C4599 bit5.n11 GND 0.02fF
C4600 bit5.n12 GND 0.01fF
C4601 bit5.n13 GND 0.02fF
C4602 bit5.n14 GND 0.41fF
C4603 bit5.n15 GND 1.99fF
C4604 bit5.t55 GND 0.14fF $ **FLOATING
C4605 bit5.n16 GND 0.03fF
C4606 bit5.n17 GND 0.02fF
C4607 bit5.t62 GND 0.14fF $ **FLOATING
C4608 bit5.n18 GND 0.04fF
C4609 bit5.n19 GND 0.02fF
C4610 bit5.n20 GND 0.01fF
C4611 bit5.n21 GND 0.02fF
C4612 bit5.n22 GND 0.41fF
C4613 bit5.n23 GND 1.98fF
C4614 bit5.t23 GND 0.14fF $ **FLOATING
C4615 bit5.n24 GND 0.03fF
C4616 bit5.n25 GND 0.02fF
C4617 bit5.t11 GND 0.14fF $ **FLOATING
C4618 bit5.n26 GND 0.04fF
C4619 bit5.n27 GND 0.02fF
C4620 bit5.n28 GND 0.01fF
C4621 bit5.n29 GND 0.02fF
C4622 bit5.n30 GND 0.41fF
C4623 bit5.n31 GND 1.98fF
C4624 bit5.t53 GND 0.14fF $ **FLOATING
C4625 bit5.n32 GND 0.03fF
C4626 bit5.n33 GND 0.02fF
C4627 bit5.t56 GND 0.14fF $ **FLOATING
C4628 bit5.n34 GND 0.04fF
C4629 bit5.n35 GND 0.02fF
C4630 bit5.n36 GND 0.01fF
C4631 bit5.n37 GND 0.02fF
C4632 bit5.n38 GND 0.41fF
C4633 bit5.n39 GND 1.98fF
C4634 bit5.t24 GND 0.14fF $ **FLOATING
C4635 bit5.n40 GND 0.03fF
C4636 bit5.n41 GND 0.02fF
C4637 bit5.t14 GND 0.14fF $ **FLOATING
C4638 bit5.n42 GND 0.04fF
C4639 bit5.n43 GND 0.02fF
C4640 bit5.n44 GND 0.01fF
C4641 bit5.n45 GND 0.02fF
C4642 bit5.n46 GND 0.41fF
C4643 bit5.n47 GND 1.98fF
C4644 bit5.t31 GND 0.14fF $ **FLOATING
C4645 bit5.n48 GND 0.03fF
C4646 bit5.n49 GND 0.02fF
C4647 bit5.t37 GND 0.14fF $ **FLOATING
C4648 bit5.n50 GND 0.04fF
C4649 bit5.n51 GND 0.02fF
C4650 bit5.n52 GND 0.01fF
C4651 bit5.n53 GND 0.02fF
C4652 bit5.n54 GND 0.41fF
C4653 bit5.n55 GND 1.98fF
C4654 bit5.n56 GND 0.02fF
C4655 bit5.n57 GND 0.01fF
C4656 bit5.t59 GND 0.14fF $ **FLOATING
C4657 bit5.n58 GND 0.04fF
C4658 bit5.n59 GND 0.02fF
C4659 bit5.t49 GND 0.14fF $ **FLOATING
C4660 bit5.n60 GND 0.03fF
C4661 bit5.n61 GND 0.02fF
C4662 bit5.n62 GND 0.41fF
C4663 bit5.n63 GND 2.00fF
C4664 bit5.t45 GND 0.14fF $ **FLOATING
C4665 bit5.n64 GND 0.03fF
C4666 bit5.n65 GND 0.02fF
C4667 bit5.t52 GND 0.14fF $ **FLOATING
C4668 bit5.n66 GND 0.04fF
C4669 bit5.n67 GND 0.02fF
C4670 bit5.n68 GND 0.01fF
C4671 bit5.n69 GND 0.02fF
C4672 bit5.n70 GND 0.64fF
C4673 bit5.t5 GND 0.14fF $ **FLOATING
C4674 bit5.n71 GND 0.03fF
C4675 bit5.n72 GND 0.02fF
C4676 bit5.t61 GND 0.14fF $ **FLOATING
C4677 bit5.n73 GND 0.04fF
C4678 bit5.n74 GND 0.02fF
C4679 bit5.n75 GND 0.01fF
C4680 bit5.n76 GND 0.02fF
C4681 bit5.n77 GND 0.41fF
C4682 bit5.n78 GND 1.99fF
C4683 bit5.t15 GND 0.14fF $ **FLOATING
C4684 bit5.n79 GND 0.03fF
C4685 bit5.n80 GND 0.02fF
C4686 bit5.t20 GND 0.14fF $ **FLOATING
C4687 bit5.n81 GND 0.04fF
C4688 bit5.n82 GND 0.02fF
C4689 bit5.n83 GND 0.01fF
C4690 bit5.n84 GND 0.02fF
C4691 bit5.n85 GND 0.41fF
C4692 bit5.n86 GND 1.98fF
C4693 bit5.t47 GND 0.14fF $ **FLOATING
C4694 bit5.n87 GND 0.03fF
C4695 bit5.n88 GND 0.02fF
C4696 bit5.t32 GND 0.14fF $ **FLOATING
C4697 bit5.n89 GND 0.04fF
C4698 bit5.n90 GND 0.02fF
C4699 bit5.n91 GND 0.01fF
C4700 bit5.n92 GND 0.02fF
C4701 bit5.n93 GND 0.41fF
C4702 bit5.n94 GND 1.98fF
C4703 bit5.t13 GND 0.14fF $ **FLOATING
C4704 bit5.n95 GND 0.03fF
C4705 bit5.n96 GND 0.02fF
C4706 bit5.t16 GND 0.14fF $ **FLOATING
C4707 bit5.n97 GND 0.04fF
C4708 bit5.n98 GND 0.02fF
C4709 bit5.n99 GND 0.01fF
C4710 bit5.n100 GND 0.02fF
C4711 bit5.n101 GND 0.41fF
C4712 bit5.n102 GND 1.98fF
C4713 bit5.t50 GND 0.14fF $ **FLOATING
C4714 bit5.n103 GND 0.03fF
C4715 bit5.n104 GND 0.02fF
C4716 bit5.t36 GND 0.14fF $ **FLOATING
C4717 bit5.n105 GND 0.04fF
C4718 bit5.n106 GND 0.02fF
C4719 bit5.n107 GND 0.01fF
C4720 bit5.n108 GND 0.02fF
C4721 bit5.n109 GND 0.41fF
C4722 bit5.n110 GND 1.98fF
C4723 bit5.t58 GND 0.14fF $ **FLOATING
C4724 bit5.n111 GND 0.03fF
C4725 bit5.n112 GND 0.02fF
C4726 bit5.t64 GND 0.14fF $ **FLOATING
C4727 bit5.n113 GND 0.04fF
C4728 bit5.n114 GND 0.02fF
C4729 bit5.n115 GND 0.01fF
C4730 bit5.n116 GND 0.02fF
C4731 bit5.n117 GND 0.41fF
C4732 bit5.n118 GND 1.98fF
C4733 bit5.t18 GND 0.14fF $ **FLOATING
C4734 bit5.n119 GND 0.03fF
C4735 bit5.n120 GND 0.02fF
C4736 bit5.t3 GND 0.14fF $ **FLOATING
C4737 bit5.n121 GND 0.04fF
C4738 bit5.n122 GND 0.02fF
C4739 bit5.n123 GND 0.01fF
C4740 bit5.n124 GND 0.02fF
C4741 bit5.n125 GND 0.41fF
C4742 bit5.n126 GND 1.57fF
C4743 bit5.n127 GND 1.76fF
C4744 bit5.t2 GND 0.14fF $ **FLOATING
C4745 bit5.n128 GND 0.03fF
C4746 bit5.n129 GND 0.02fF
C4747 bit5.t9 GND 0.14fF $ **FLOATING
C4748 bit5.n130 GND 0.04fF
C4749 bit5.n131 GND 0.02fF
C4750 bit5.n132 GND 0.01fF
C4751 bit5.n133 GND 0.02fF
C4752 bit5.n134 GND 0.64fF
C4753 bit5.t29 GND 0.14fF $ **FLOATING
C4754 bit5.n135 GND 0.03fF
C4755 bit5.n136 GND 0.02fF
C4756 bit5.t19 GND 0.14fF $ **FLOATING
C4757 bit5.n137 GND 0.04fF
C4758 bit5.n138 GND 0.02fF
C4759 bit5.n139 GND 0.01fF
C4760 bit5.n140 GND 0.02fF
C4761 bit5.n141 GND 0.41fF
C4762 bit5.n142 GND 1.99fF
C4763 bit5.t38 GND 0.14fF $ **FLOATING
C4764 bit5.n143 GND 0.03fF
C4765 bit5.n144 GND 0.02fF
C4766 bit5.t42 GND 0.14fF $ **FLOATING
C4767 bit5.n145 GND 0.04fF
C4768 bit5.n146 GND 0.02fF
C4769 bit5.n147 GND 0.01fF
C4770 bit5.n148 GND 0.02fF
C4771 bit5.n149 GND 0.41fF
C4772 bit5.n150 GND 1.98fF
C4773 bit5.t4 GND 0.14fF $ **FLOATING
C4774 bit5.n151 GND 0.03fF
C4775 bit5.n152 GND 0.02fF
C4776 bit5.t60 GND 0.14fF $ **FLOATING
C4777 bit5.n153 GND 0.04fF
C4778 bit5.n154 GND 0.02fF
C4779 bit5.n155 GND 0.01fF
C4780 bit5.n156 GND 0.02fF
C4781 bit5.n157 GND 0.41fF
C4782 bit5.n158 GND 1.98fF
C4783 bit5.t35 GND 0.14fF $ **FLOATING
C4784 bit5.n159 GND 0.03fF
C4785 bit5.n160 GND 0.02fF
C4786 bit5.t40 GND 0.14fF $ **FLOATING
C4787 bit5.n161 GND 0.04fF
C4788 bit5.n162 GND 0.02fF
C4789 bit5.n163 GND 0.01fF
C4790 bit5.n164 GND 0.02fF
C4791 bit5.n165 GND 0.41fF
C4792 bit5.n166 GND 1.98fF
C4793 bit5.t7 GND 0.14fF $ **FLOATING
C4794 bit5.n167 GND 0.03fF
C4795 bit5.n168 GND 0.02fF
C4796 bit5.t63 GND 0.14fF $ **FLOATING
C4797 bit5.n169 GND 0.04fF
C4798 bit5.n170 GND 0.02fF
C4799 bit5.n171 GND 0.01fF
C4800 bit5.n172 GND 0.02fF
C4801 bit5.n173 GND 0.41fF
C4802 bit5.n174 GND 1.98fF
C4803 bit5.t17 GND 0.14fF $ **FLOATING
C4804 bit5.n175 GND 0.03fF
C4805 bit5.n176 GND 0.02fF
C4806 bit5.t21 GND 0.14fF $ **FLOATING
C4807 bit5.n177 GND 0.04fF
C4808 bit5.n178 GND 0.02fF
C4809 bit5.n179 GND 0.01fF
C4810 bit5.n180 GND 0.02fF
C4811 bit5.n181 GND 0.41fF
C4812 bit5.n182 GND 1.98fF
C4813 bit5.t41 GND 0.14fF $ **FLOATING
C4814 bit5.n183 GND 0.03fF
C4815 bit5.n184 GND 0.02fF
C4816 bit5.t27 GND 0.14fF $ **FLOATING
C4817 bit5.n185 GND 0.04fF
C4818 bit5.n186 GND 0.02fF
C4819 bit5.n187 GND 0.01fF
C4820 bit5.n188 GND 0.02fF
C4821 bit5.n189 GND 0.41fF
C4822 bit5.n190 GND 1.57fF
C4823 bit5.n191 GND 1.22fF
C4824 bit5.n192 GND 1.03fF
C4825 bit5.t34 GND 0.14fF $ **FLOATING
C4826 bit5.n193 GND 0.03fF
C4827 bit5.n194 GND 0.02fF
C4828 bit5.t54 GND 0.14fF $ **FLOATING
C4829 bit5.n195 GND 0.04fF
C4830 bit5.n196 GND 0.02fF
C4831 bit5.n197 GND 0.01fF
C4832 bit5.n198 GND 0.02fF
C4833 bit5.n199 GND 0.41fF
C4834 bit5.n200 GND 1.65fF
C4835 bit5.t28 GND 0.14fF $ **FLOATING
C4836 bit5.n201 GND 0.03fF
C4837 bit5.n202 GND 0.02fF
C4838 bit5.t30 GND 0.14fF $ **FLOATING
C4839 bit5.n203 GND 0.04fF
C4840 bit5.n204 GND 0.02fF
C4841 bit5.n205 GND 0.01fF
C4842 bit5.n206 GND 0.02fF
C4843 bit5.n207 GND 0.41fF
C4844 bit5.n208 GND 1.98fF
C4845 bit5.t6 GND 0.14fF $ **FLOATING
C4846 bit5.n209 GND 0.03fF
C4847 bit5.n210 GND 0.02fF
C4848 bit5.t25 GND 0.14fF $ **FLOATING
C4849 bit5.n211 GND 0.04fF
C4850 bit5.n212 GND 0.02fF
C4851 bit5.n213 GND 0.01fF
C4852 bit5.n214 GND 0.02fF
C4853 bit5.n215 GND 0.41fF
C4854 bit5.n216 GND 1.98fF
C4855 bit5.t65 GND 0.14fF $ **FLOATING
C4856 bit5.n217 GND 0.03fF
C4857 bit5.n218 GND 0.02fF
C4858 bit5.t0 GND 0.14fF $ **FLOATING
C4859 bit5.n219 GND 0.04fF
C4860 bit5.n220 GND 0.02fF
C4861 bit5.n221 GND 0.01fF
C4862 bit5.n222 GND 0.02fF
C4863 bit5.n223 GND 0.41fF
C4864 bit5.n224 GND 1.98fF
C4865 bit5.t57 GND 0.14fF $ **FLOATING
C4866 bit5.n225 GND 0.03fF
C4867 bit5.n226 GND 0.02fF
C4868 bit5.t12 GND 0.14fF $ **FLOATING
C4869 bit5.n227 GND 0.04fF
C4870 bit5.n228 GND 0.02fF
C4871 bit5.n229 GND 0.01fF
C4872 bit5.n230 GND 0.02fF
C4873 bit5.n231 GND 0.41fF
C4874 bit5.n232 GND 1.98fF
C4875 bit5.t8 GND 0.14fF $ **FLOATING
C4876 bit5.n233 GND 0.03fF
C4877 bit5.n234 GND 0.02fF
C4878 bit5.t10 GND 0.14fF $ **FLOATING
C4879 bit5.n235 GND 0.04fF
C4880 bit5.n236 GND 0.02fF
C4881 bit5.n237 GND 0.01fF
C4882 bit5.n238 GND 0.02fF
C4883 bit5.n239 GND 0.41fF
C4884 bit5.n240 GND 1.98fF
C4885 bit5.t51 GND 0.14fF $ **FLOATING
C4886 bit5.n241 GND 0.03fF
C4887 bit5.n242 GND 0.02fF
C4888 bit5.t1 GND 0.14fF $ **FLOATING
C4889 bit5.n243 GND 0.04fF
C4890 bit5.n244 GND 0.02fF
C4891 bit5.n245 GND 0.01fF
C4892 bit5.n246 GND 0.02fF
C4893 bit5.n247 GND 0.41fF
C4894 bit5.n248 GND 1.98fF
C4895 bit5.t43 GND 0.14fF $ **FLOATING
C4896 bit5.n249 GND 0.03fF
C4897 bit5.n250 GND 0.02fF
C4898 bit5.t44 GND 0.14fF $ **FLOATING
C4899 bit5.n251 GND 0.04fF
C4900 bit5.n252 GND 0.02fF
C4901 bit5.n253 GND 0.01fF
C4902 bit5.n254 GND 0.02fF
C4903 bit5.n255 GND 0.41fF
C4904 bit5.n256 GND 1.64fF
C4905 a_1706_15242.n0 GND 0.00fF
C4906 a_1706_15242.n1 GND 0.00fF
C4907 a_1706_15242.n2 GND 0.01fF
C4908 a_1706_15242.n3 GND 0.01fF
C4909 a_1706_15242.n4 GND 0.00fF
C4910 a_1706_15242.n5 GND 0.01fF
C4911 a_1706_15242.n6 GND 0.00fF
C4912 a_1706_15242.n7 GND 0.00fF
C4913 a_1706_15242.n8 GND 0.00fF
C4914 a_1706_15242.n9 GND 0.00fF
C4915 a_1706_15242.n10 GND 0.09fF
C4916 a_1706_15242.n11 GND 0.00fF
C4917 a_1706_15242.n12 GND 0.01fF
C4918 a_1706_15242.n13 GND 0.01fF
C4919 a_1706_15242.n14 GND 0.01fF
C4920 a_1706_15242.n15 GND 0.00fF
C4921 a_1706_15242.n16 GND 0.00fF
C4922 a_1706_15242.n17 GND 0.00fF
C4923 a_1706_15242.t1 GND 0.02fF $ **FLOATING
C4924 a_1706_15242.n18 GND 0.07fF
C4925 a_1706_15242.n19 GND 0.02fF
C4926 a_1706_15242.n20 GND 0.05fF
C4927 a_1706_15242.n22 GND 0.04fF
C4928 a_1706_15242.n23 GND 0.04fF
C4929 a_1706_15242.n24 GND 0.00fF
C4930 a_1706_15242.n25 GND 0.00fF
C4931 a_1706_15242.t0 GND 0.02fF $ **FLOATING
C4932 a_1706_15242.n26 GND 0.07fF
C4933 a_1706_15242.n27 GND 0.02fF
C4934 a_1706_15242.n28 GND 0.05fF
C4935 a_1706_15242.n30 GND 0.01fF
C4936 a_1706_15242.n31 GND 0.00fF
C4937 a_1706_15242.n32 GND 0.01fF
C4938 a_1706_15242.n33 GND 0.00fF
C4939 a_1706_15242.n34 GND 0.00fF
C4940 a_1706_15242.n35 GND 0.00fF
C4941 a_1706_15242.n36 GND 0.00fF
C4942 a_1706_15242.n38 GND 0.08fF
C4943 a_1706_15242.t3 GND 4.25fF $ **FLOATING
C4944 a_1706_15242.n39 GND 0.62fF
C4945 a_1706_15242.t2 GND 0.26fF $ **FLOATING
C4946 OUT_N.t37 GND 1.51fF $ **FLOATING
C4947 OUT_N.t58 GND 1.48fF $ **FLOATING
C4948 OUT_N.n0 GND 0.40fF
C4949 OUT_N.t28 GND 1.48fF $ **FLOATING
C4950 OUT_N.n1 GND 0.40fF
C4951 OUT_N.t62 GND 1.48fF $ **FLOATING
C4952 OUT_N.n2 GND 0.40fF
C4953 OUT_N.t60 GND 1.48fF $ **FLOATING
C4954 OUT_N.n3 GND 0.40fF
C4955 OUT_N.t30 GND 1.48fF $ **FLOATING
C4956 OUT_N.n4 GND 0.40fF
C4957 OUT_N.t10 GND 1.48fF $ **FLOATING
C4958 OUT_N.n5 GND 0.84fF
C4959 OUT_N.t1 GND 1.51fF $ **FLOATING
C4960 OUT_N.t51 GND 1.48fF $ **FLOATING
C4961 OUT_N.n6 GND 0.40fF
C4962 OUT_N.t23 GND 1.48fF $ **FLOATING
C4963 OUT_N.n7 GND 0.40fF
C4964 OUT_N.t57 GND 1.48fF $ **FLOATING
C4965 OUT_N.n8 GND 0.40fF
C4966 OUT_N.t54 GND 1.48fF $ **FLOATING
C4967 OUT_N.n9 GND 0.40fF
C4968 OUT_N.t25 GND 1.48fF $ **FLOATING
C4969 OUT_N.n10 GND 0.40fF
C4970 OUT_N.t11 GND 1.48fF $ **FLOATING
C4971 OUT_N.n11 GND 0.84fF
C4972 OUT_N.t27 GND 1.51fF $ **FLOATING
C4973 OUT_N.t34 GND 1.48fF $ **FLOATING
C4974 OUT_N.n12 GND 0.40fF
C4975 OUT_N.t3 GND 1.48fF $ **FLOATING
C4976 OUT_N.n13 GND 0.40fF
C4977 OUT_N.t39 GND 1.48fF $ **FLOATING
C4978 OUT_N.n14 GND 0.40fF
C4979 OUT_N.t38 GND 1.48fF $ **FLOATING
C4980 OUT_N.n15 GND 0.40fF
C4981 OUT_N.t4 GND 1.48fF $ **FLOATING
C4982 OUT_N.n16 GND 0.40fF
C4983 OUT_N.t55 GND 1.48fF $ **FLOATING
C4984 OUT_N.n17 GND 0.84fF
C4985 OUT_N.t41 GND 1.51fF $ **FLOATING
C4986 OUT_N.t8 GND 1.48fF $ **FLOATING
C4987 OUT_N.n18 GND 0.40fF
C4988 OUT_N.t40 GND 1.48fF $ **FLOATING
C4989 OUT_N.n19 GND 0.40fF
C4990 OUT_N.t12 GND 1.48fF $ **FLOATING
C4991 OUT_N.n20 GND 0.40fF
C4992 OUT_N.t9 GND 1.48fF $ **FLOATING
C4993 OUT_N.n21 GND 0.40fF
C4994 OUT_N.t42 GND 1.48fF $ **FLOATING
C4995 OUT_N.n22 GND 0.40fF
C4996 OUT_N.t53 GND 1.48fF $ **FLOATING
C4997 OUT_N.n23 GND 0.84fF
C4998 OUT_N.t2 GND 1.51fF $ **FLOATING
C4999 OUT_N.t50 GND 1.48fF $ **FLOATING
C5000 OUT_N.n24 GND 0.40fF
C5001 OUT_N.t22 GND 1.48fF $ **FLOATING
C5002 OUT_N.n25 GND 0.40fF
C5003 OUT_N.t56 GND 1.48fF $ **FLOATING
C5004 OUT_N.n26 GND 0.40fF
C5005 OUT_N.t52 GND 1.48fF $ **FLOATING
C5006 OUT_N.n27 GND 0.40fF
C5007 OUT_N.t24 GND 1.48fF $ **FLOATING
C5008 OUT_N.n28 GND 0.40fF
C5009 OUT_N.t35 GND 1.48fF $ **FLOATING
C5010 OUT_N.n29 GND 0.40fF
C5011 OUT_N.t6 GND 1.48fF $ **FLOATING
C5012 OUT_N.n30 GND 0.67fF
C5013 OUT_N.t31 GND 1.51fF $ **FLOATING
C5014 OUT_N.t44 GND 1.48fF $ **FLOATING
C5015 OUT_N.n31 GND 0.40fF
C5016 OUT_N.t15 GND 1.48fF $ **FLOATING
C5017 OUT_N.n32 GND 0.40fF
C5018 OUT_N.t49 GND 1.48fF $ **FLOATING
C5019 OUT_N.n33 GND 0.40fF
C5020 OUT_N.t46 GND 1.48fF $ **FLOATING
C5021 OUT_N.n34 GND 0.40fF
C5022 OUT_N.t17 GND 1.48fF $ **FLOATING
C5023 OUT_N.n35 GND 0.40fF
C5024 OUT_N.t36 GND 1.48fF $ **FLOATING
C5025 OUT_N.n36 GND 0.40fF
C5026 OUT_N.t7 GND 1.48fF $ **FLOATING
C5027 OUT_N.n37 GND 0.67fF
C5028 OUT_N.t5 GND 1.51fF $ **FLOATING
C5029 OUT_N.t14 GND 1.48fF $ **FLOATING
C5030 OUT_N.n38 GND 0.40fF
C5031 OUT_N.t43 GND 1.48fF $ **FLOATING
C5032 OUT_N.n39 GND 0.40fF
C5033 OUT_N.t20 GND 1.48fF $ **FLOATING
C5034 OUT_N.n40 GND 0.40fF
C5035 OUT_N.t16 GND 1.48fF $ **FLOATING
C5036 OUT_N.n41 GND 0.40fF
C5037 OUT_N.t45 GND 1.48fF $ **FLOATING
C5038 OUT_N.n42 GND 0.40fF
C5039 OUT_N.t26 GND 1.48fF $ **FLOATING
C5040 OUT_N.n43 GND 0.40fF
C5041 OUT_N.t59 GND 1.48fF $ **FLOATING
C5042 OUT_N.n44 GND 0.40fF
C5043 OUT_N.t29 GND 1.48fF $ **FLOATING
C5044 OUT_N.n45 GND 0.49fF
C5045 OUT_N.t13 GND 1.51fF $ **FLOATING
C5046 OUT_N.t18 GND 1.48fF $ **FLOATING
C5047 OUT_N.n46 GND 0.40fF
C5048 OUT_N.t47 GND 1.48fF $ **FLOATING
C5049 OUT_N.n47 GND 0.40fF
C5050 OUT_N.t21 GND 1.48fF $ **FLOATING
C5051 OUT_N.n48 GND 0.40fF
C5052 OUT_N.t19 GND 1.48fF $ **FLOATING
C5053 OUT_N.n49 GND 0.40fF
C5054 OUT_N.t48 GND 1.48fF $ **FLOATING
C5055 OUT_N.n50 GND 0.40fF
C5056 OUT_N.t61 GND 1.48fF $ **FLOATING
C5057 OUT_N.n51 GND 0.40fF
C5058 OUT_N.t32 GND 1.48fF $ **FLOATING
C5059 OUT_N.n52 GND 0.40fF
C5060 OUT_N.t0 GND 1.48fF $ **FLOATING
C5061 OUT_N.n53 GND 0.40fF
C5062 OUT_N.t33 GND 1.48fF $ **FLOATING
C5063 OUT_N.n54 GND 1.44fF
C5064 OUT_N.n55 GND 1.28fF
C5065 OUT_N.n56 GND 1.19fF
C5066 OUT_N.n57 GND 1.19fF
C5067 OUT_N.n58 GND 1.36fF
C5068 OUT_N.n59 GND 1.36fF
C5069 OUT_N.n60 GND 1.36fF
C5070 OUT_N.n61 GND 1.06fF
C5071 a_1416_4186.n0 GND 0.01fF
C5072 a_1416_4186.n1 GND 0.01fF
C5073 a_1416_4186.n2 GND 0.00fF
C5074 a_1416_4186.n3 GND 0.00fF
C5075 a_1416_4186.n4 GND 0.00fF
C5076 a_1416_4186.n5 GND 0.00fF
C5077 a_1416_4186.n6 GND 0.00fF
C5078 a_1416_4186.n7 GND 0.00fF
C5079 a_1416_4186.n8 GND 0.00fF
C5080 a_1416_4186.n9 GND 0.00fF
C5081 a_1416_4186.t0 GND 0.02fF $ **FLOATING
C5082 a_1416_4186.t1 GND 0.02fF $ **FLOATING
C5083 a_1416_4186.n10 GND 0.05fF
C5084 a_1416_4186.n11 GND 0.00fF
C5085 a_1416_4186.n12 GND 0.00fF
C5086 a_1416_4186.n13 GND 0.02fF
C5087 a_1416_4186.n14 GND 0.05fF
C5088 a_1416_4186.n15 GND 0.13fF
C5089 a_1416_4186.n16 GND 0.01fF
C5090 a_1416_4186.n17 GND 0.12fF
C5091 a_1416_4186.t3 GND 3.94fF $ **FLOATING
C5092 a_1416_4186.n18 GND 0.53fF
C5093 a_1416_4186.t2 GND 0.24fF $ **FLOATING
C5094 a_5456_13412.n0 GND 0.00fF
C5095 a_5456_13412.n1 GND 0.00fF
C5096 a_5456_13412.n2 GND 0.01fF
C5097 a_5456_13412.n3 GND 0.01fF
C5098 a_5456_13412.n4 GND 0.00fF
C5099 a_5456_13412.n5 GND 0.01fF
C5100 a_5456_13412.n6 GND 0.00fF
C5101 a_5456_13412.n7 GND 0.00fF
C5102 a_5456_13412.n8 GND 0.00fF
C5103 a_5456_13412.n9 GND 0.00fF
C5104 a_5456_13412.n10 GND 0.09fF
C5105 a_5456_13412.n11 GND 0.00fF
C5106 a_5456_13412.n12 GND 0.01fF
C5107 a_5456_13412.n13 GND 0.01fF
C5108 a_5456_13412.n14 GND 0.01fF
C5109 a_5456_13412.n15 GND 0.00fF
C5110 a_5456_13412.n16 GND 0.00fF
C5111 a_5456_13412.n17 GND 0.00fF
C5112 a_5456_13412.t1 GND 0.02fF $ **FLOATING
C5113 a_5456_13412.n18 GND 0.07fF
C5114 a_5456_13412.n19 GND 0.02fF
C5115 a_5456_13412.n20 GND 0.05fF
C5116 a_5456_13412.n22 GND 0.04fF
C5117 a_5456_13412.n23 GND 0.04fF
C5118 a_5456_13412.n24 GND 0.00fF
C5119 a_5456_13412.n25 GND 0.00fF
C5120 a_5456_13412.t2 GND 0.02fF $ **FLOATING
C5121 a_5456_13412.n26 GND 0.07fF
C5122 a_5456_13412.n27 GND 0.02fF
C5123 a_5456_13412.n28 GND 0.05fF
C5124 a_5456_13412.n30 GND 0.01fF
C5125 a_5456_13412.n31 GND 0.00fF
C5126 a_5456_13412.n32 GND 0.01fF
C5127 a_5456_13412.n33 GND 0.00fF
C5128 a_5456_13412.n34 GND 0.00fF
C5129 a_5456_13412.n35 GND 0.00fF
C5130 a_5456_13412.n36 GND 0.00fF
C5131 a_5456_13412.n38 GND 0.08fF
C5132 a_5456_13412.t0 GND 4.25fF $ **FLOATING
C5133 a_5456_13412.n39 GND 0.62fF
C5134 a_5456_13412.t3 GND 0.26fF $ **FLOATING
C5135 a_5166_13336.n0 GND 0.01fF
C5136 a_5166_13336.n1 GND 0.01fF
C5137 a_5166_13336.n2 GND 0.00fF
C5138 a_5166_13336.n3 GND 0.00fF
C5139 a_5166_13336.n4 GND 0.00fF
C5140 a_5166_13336.n5 GND 0.00fF
C5141 a_5166_13336.n6 GND 0.00fF
C5142 a_5166_13336.n7 GND 0.00fF
C5143 a_5166_13336.n8 GND 0.00fF
C5144 a_5166_13336.n9 GND 0.00fF
C5145 a_5166_13336.t1 GND 0.02fF $ **FLOATING
C5146 a_5166_13336.t2 GND 0.02fF $ **FLOATING
C5147 a_5166_13336.n10 GND 0.05fF
C5148 a_5166_13336.n11 GND 0.00fF
C5149 a_5166_13336.n12 GND 0.00fF
C5150 a_5166_13336.n13 GND 0.02fF
C5151 a_5166_13336.n14 GND 0.05fF
C5152 a_5166_13336.n15 GND 0.13fF
C5153 a_5166_13336.n16 GND 0.01fF
C5154 a_5166_13336.n17 GND 0.12fF
C5155 a_5166_13336.t0 GND 3.94fF $ **FLOATING
C5156 a_5166_13336.n18 GND 0.53fF
C5157 a_5166_13336.t3 GND 0.24fF $ **FLOATING
C5158 bit2.t6 GND 0.06fF $ **FLOATING
C5159 bit2.t9 GND 0.03fF $ **FLOATING
C5160 bit2.n0 GND 0.08fF
C5161 bit2.n1 GND 0.01fF
C5162 bit2.n2 GND 0.01fF
C5163 bit2.t4 GND 0.12fF $ **FLOATING
C5164 bit2.n3 GND 0.03fF
C5165 bit2.n4 GND 0.02fF
C5166 bit2.t1 GND 0.12fF $ **FLOATING
C5167 bit2.n5 GND 0.03fF
C5168 bit2.n6 GND 0.02fF
C5169 bit2.n7 GND 0.35fF
C5170 bit2.n8 GND 1.99fF
C5171 bit2.t8 GND 0.12fF $ **FLOATING
C5172 bit2.n9 GND 0.03fF
C5173 bit2.n10 GND 0.02fF
C5174 bit2.t0 GND 0.12fF $ **FLOATING
C5175 bit2.n11 GND 0.03fF
C5176 bit2.n12 GND 0.01fF
C5177 bit2.n13 GND 0.01fF
C5178 bit2.n14 GND 0.02fF
C5179 bit2.n15 GND 0.35fF
C5180 bit2.n16 GND 1.68fF
C5181 bit2.t7 GND 0.12fF $ **FLOATING
C5182 bit2.n17 GND 0.03fF
C5183 bit2.n18 GND 0.02fF
C5184 bit2.t3 GND 0.12fF $ **FLOATING
C5185 bit2.n19 GND 0.03fF
C5186 bit2.n20 GND 0.01fF
C5187 bit2.n21 GND 0.01fF
C5188 bit2.n22 GND 0.02fF
C5189 bit2.n23 GND 0.35fF
C5190 bit2.n24 GND 1.68fF
C5191 bit2.t2 GND 0.12fF $ **FLOATING
C5192 bit2.n25 GND 0.03fF
C5193 bit2.n26 GND 0.02fF
C5194 bit2.t5 GND 0.12fF $ **FLOATING
C5195 bit2.n27 GND 0.03fF
C5196 bit2.n28 GND 0.01fF
C5197 bit2.n29 GND 0.01fF
C5198 bit2.n30 GND 0.02fF
C5199 bit2.n31 GND 0.35fF
C5200 bit2.n32 GND 4.45fF
C5201 a_12666_7846.n0 GND 0.01fF
C5202 a_12666_7846.n1 GND 0.01fF
C5203 a_12666_7846.n2 GND 0.00fF
C5204 a_12666_7846.n3 GND 0.00fF
C5205 a_12666_7846.n4 GND 0.00fF
C5206 a_12666_7846.n5 GND 0.00fF
C5207 a_12666_7846.n6 GND 0.00fF
C5208 a_12666_7846.n7 GND 0.00fF
C5209 a_12666_7846.n8 GND 0.00fF
C5210 a_12666_7846.n9 GND 0.00fF
C5211 a_12666_7846.t1 GND 0.02fF $ **FLOATING
C5212 a_12666_7846.t0 GND 0.02fF $ **FLOATING
C5213 a_12666_7846.n10 GND 0.05fF
C5214 a_12666_7846.n11 GND 0.00fF
C5215 a_12666_7846.n12 GND 0.00fF
C5216 a_12666_7846.n13 GND 0.02fF
C5217 a_12666_7846.n14 GND 0.05fF
C5218 a_12666_7846.n15 GND 0.13fF
C5219 a_12666_7846.n16 GND 0.01fF
C5220 a_12666_7846.n17 GND 0.12fF
C5221 a_12666_7846.t3 GND 3.94fF $ **FLOATING
C5222 a_12666_7846.n18 GND 0.53fF
C5223 a_12666_7846.t2 GND 0.24fF $ **FLOATING
C5224 OUT_P.t12 GND 1.53fF $ **FLOATING
C5225 OUT_P.t35 GND 1.51fF $ **FLOATING
C5226 OUT_P.n0 GND 0.41fF
C5227 OUT_P.t1 GND 1.51fF $ **FLOATING
C5228 OUT_P.n1 GND 0.40fF
C5229 OUT_P.t39 GND 1.51fF $ **FLOATING
C5230 OUT_P.n2 GND 0.40fF
C5231 OUT_P.t38 GND 1.51fF $ **FLOATING
C5232 OUT_P.n3 GND 0.40fF
C5233 OUT_P.t2 GND 1.51fF $ **FLOATING
C5234 OUT_P.n4 GND 0.40fF
C5235 OUT_P.t13 GND 1.51fF $ **FLOATING
C5236 OUT_P.n5 GND 0.40fF
C5237 OUT_P.t46 GND 1.51fF $ **FLOATING
C5238 OUT_P.n6 GND 0.40fF
C5239 OUT_P.t16 GND 1.51fF $ **FLOATING
C5240 OUT_P.n7 GND 0.40fF
C5241 OUT_P.t47 GND 1.51fF $ **FLOATING
C5242 OUT_P.n8 GND 0.31fF
C5243 OUT_P.t45 GND 1.53fF $ **FLOATING
C5244 OUT_P.t30 GND 1.51fF $ **FLOATING
C5245 OUT_P.n9 GND 0.41fF
C5246 OUT_P.t58 GND 1.51fF $ **FLOATING
C5247 OUT_P.n10 GND 0.40fF
C5248 OUT_P.t33 GND 1.51fF $ **FLOATING
C5249 OUT_P.n11 GND 0.40fF
C5250 OUT_P.t32 GND 1.51fF $ **FLOATING
C5251 OUT_P.n12 GND 0.40fF
C5252 OUT_P.t61 GND 1.51fF $ **FLOATING
C5253 OUT_P.n13 GND 0.40fF
C5254 OUT_P.t29 GND 1.51fF $ **FLOATING
C5255 OUT_P.n14 GND 0.40fF
C5256 OUT_P.t59 GND 1.51fF $ **FLOATING
C5257 OUT_P.n15 GND 0.40fF
C5258 OUT_P.t31 GND 1.51fF $ **FLOATING
C5259 OUT_P.n16 GND 0.49fF
C5260 OUT_P.t60 GND 1.53fF $ **FLOATING
C5261 OUT_P.t54 GND 1.51fF $ **FLOATING
C5262 OUT_P.n17 GND 0.41fF
C5263 OUT_P.t26 GND 1.51fF $ **FLOATING
C5264 OUT_P.n18 GND 0.40fF
C5265 OUT_P.t57 GND 1.51fF $ **FLOATING
C5266 OUT_P.n19 GND 0.40fF
C5267 OUT_P.t56 GND 1.51fF $ **FLOATING
C5268 OUT_P.n20 GND 0.40fF
C5269 OUT_P.t27 GND 1.51fF $ **FLOATING
C5270 OUT_P.n21 GND 0.40fF
C5271 OUT_P.t18 GND 1.51fF $ **FLOATING
C5272 OUT_P.n22 GND 0.40fF
C5273 OUT_P.t51 GND 1.51fF $ **FLOATING
C5274 OUT_P.n23 GND 0.66fF
C5275 OUT_P.t41 GND 1.53fF $ **FLOATING
C5276 OUT_P.t62 GND 1.51fF $ **FLOATING
C5277 OUT_P.n24 GND 0.41fF
C5278 OUT_P.t34 GND 1.51fF $ **FLOATING
C5279 OUT_P.n25 GND 0.40fF
C5280 OUT_P.t3 GND 1.51fF $ **FLOATING
C5281 OUT_P.n26 GND 0.40fF
C5282 OUT_P.t0 GND 1.51fF $ **FLOATING
C5283 OUT_P.n27 GND 0.40fF
C5284 OUT_P.t36 GND 1.51fF $ **FLOATING
C5285 OUT_P.n28 GND 0.40fF
C5286 OUT_P.t37 GND 1.51fF $ **FLOATING
C5287 OUT_P.n29 GND 0.40fF
C5288 OUT_P.t4 GND 1.51fF $ **FLOATING
C5289 OUT_P.n30 GND 0.66fF
C5290 OUT_P.t17 GND 1.53fF $ **FLOATING
C5291 OUT_P.t23 GND 1.51fF $ **FLOATING
C5292 OUT_P.n31 GND 0.41fF
C5293 OUT_P.t52 GND 1.51fF $ **FLOATING
C5294 OUT_P.n32 GND 0.40fF
C5295 OUT_P.t28 GND 1.51fF $ **FLOATING
C5296 OUT_P.n33 GND 0.40fF
C5297 OUT_P.t24 GND 1.51fF $ **FLOATING
C5298 OUT_P.n34 GND 0.40fF
C5299 OUT_P.t53 GND 1.51fF $ **FLOATING
C5300 OUT_P.n35 GND 0.40fF
C5301 OUT_P.t55 GND 1.51fF $ **FLOATING
C5302 OUT_P.n36 GND 0.84fF
C5303 OUT_P.t6 GND 1.53fF $ **FLOATING
C5304 OUT_P.t20 GND 1.51fF $ **FLOATING
C5305 OUT_P.n37 GND 0.41fF
C5306 OUT_P.t49 GND 1.51fF $ **FLOATING
C5307 OUT_P.n38 GND 0.40fF
C5308 OUT_P.t25 GND 1.51fF $ **FLOATING
C5309 OUT_P.n39 GND 0.40fF
C5310 OUT_P.t22 GND 1.51fF $ **FLOATING
C5311 OUT_P.n40 GND 0.40fF
C5312 OUT_P.t50 GND 1.51fF $ **FLOATING
C5313 OUT_P.n41 GND 0.40fF
C5314 OUT_P.t21 GND 1.51fF $ **FLOATING
C5315 OUT_P.n42 GND 0.84fF
C5316 OUT_P.t19 GND 1.53fF $ **FLOATING
C5317 OUT_P.t8 GND 1.51fF $ **FLOATING
C5318 OUT_P.n43 GND 0.41fF
C5319 OUT_P.t43 GND 1.51fF $ **FLOATING
C5320 OUT_P.n44 GND 0.40fF
C5321 OUT_P.t14 GND 1.51fF $ **FLOATING
C5322 OUT_P.n45 GND 0.40fF
C5323 OUT_P.t10 GND 1.51fF $ **FLOATING
C5324 OUT_P.n46 GND 0.40fF
C5325 OUT_P.t44 GND 1.51fF $ **FLOATING
C5326 OUT_P.n47 GND 0.40fF
C5327 OUT_P.t48 GND 1.51fF $ **FLOATING
C5328 OUT_P.n48 GND 0.84fF
C5329 OUT_P.t9 GND 1.53fF $ **FLOATING
C5330 OUT_P.t5 GND 1.51fF $ **FLOATING
C5331 OUT_P.n49 GND 0.41fF
C5332 OUT_P.t40 GND 1.51fF $ **FLOATING
C5333 OUT_P.n50 GND 0.40fF
C5334 OUT_P.t11 GND 1.51fF $ **FLOATING
C5335 OUT_P.n51 GND 0.40fF
C5336 OUT_P.t7 GND 1.51fF $ **FLOATING
C5337 OUT_P.n52 GND 0.40fF
C5338 OUT_P.t42 GND 1.51fF $ **FLOATING
C5339 OUT_P.n53 GND 0.40fF
C5340 OUT_P.t15 GND 1.51fF $ **FLOATING
C5341 OUT_P.n54 GND 1.51fF
C5342 OUT_P.n55 GND 2.52fF
C5343 OUT_P.n56 GND 1.40fF
C5344 OUT_P.n57 GND 1.40fF
C5345 OUT_P.n58 GND 1.22fF
C5346 OUT_P.n59 GND 1.22fF
C5347 OUT_P.n60 GND 1.04fF
C5348 OUT_P.n61 GND 0.65fF


**** end user architecture code
**.ends
.end

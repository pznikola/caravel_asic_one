v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 180 -350 180 -290 {
lab=w_inv5}
N 230 -350 230 -290 {
lab=bit5}
N -50 0 0 0 {
lab=OUT_P}
N 450 0 530 -0 {
lab=OUT_N}
N 230 80 230 140 {
lab=GND}
N 900 -350 900 -290 {
lab=w_inv5}
N 950 -350 950 -290 {
lab=bit5}
N 670 0 720 0 {
lab=OUT_P}
N 1170 0 1250 0 {
lab=OUT_N}
N 950 80 950 140 {
lab=GND}
N 1610 -350 1610 -290 {
lab=w_inv5}
N 1660 -350 1660 -290 {
lab=bit5}
N 1380 0 1430 0 {
lab=OUT_P}
N 1880 0 1960 0 {
lab=OUT_N}
N 1660 80 1660 140 {
lab=GND}
N 2320 -350 2320 -290 {
lab=w_inv5}
N 2370 -350 2370 -290 {
lab=bit5}
N 2090 0 2140 0 {
lab=OUT_P}
N 2590 0 2670 0 {
lab=OUT_N}
N 2370 80 2370 140 {
lab=GND}
N 3020 -350 3020 -290 {
lab=w_inv5}
N 3070 -350 3070 -290 {
lab=bit5}
N 2790 0 2840 0 {
lab=OUT_P}
N 3290 0 3370 0 {
lab=OUT_N}
N 3070 80 3070 140 {
lab=GND}
N 3740 -350 3740 -290 {
lab=w_inv5}
N 3790 -350 3790 -290 {
lab=bit5}
N 3510 0 3560 0 {
lab=OUT_P}
N 4010 0 4090 0 {
lab=OUT_N}
N 3790 80 3790 140 {
lab=GND}
N 4450 -350 4450 -290 {
lab=w_inv5}
N 4500 -350 4500 -290 {
lab=bit5}
N 4220 0 4270 0 {
lab=OUT_P}
N 4720 0 4800 0 {
lab=OUT_N}
N 4500 80 4500 140 {
lab=GND}
N 5160 -350 5160 -290 {
lab=w_inv5}
N 5210 -350 5210 -290 {
lab=bit5}
N 4930 0 4980 0 {
lab=OUT_P}
N 5430 0 5510 0 {
lab=OUT_N}
N 5210 80 5210 140 {
lab=GND}
N 5860 -350 5860 -290 {
lab=w_inv5}
N 5910 -350 5910 -290 {
lab=bit5}
N 5630 0 5680 0 {
lab=OUT_P}
N 6130 0 6210 0 {
lab=OUT_N}
N 5910 80 5910 140 {
lab=GND}
N 6580 -350 6580 -290 {
lab=w_inv5}
N 6630 -350 6630 -290 {
lab=bit5}
N 6350 0 6400 0 {
lab=OUT_P}
N 6850 0 6930 0 {
lab=OUT_N}
N 6630 80 6630 140 {
lab=GND}
N 7300 -350 7300 -290 {
lab=w_inv5}
N 7350 -350 7350 -290 {
lab=bit5}
N 7070 0 7120 0 {
lab=OUT_P}
N 7570 0 7650 0 {
lab=OUT_N}
N 7350 80 7350 140 {
lab=GND}
N 8030 -350 8030 -290 {
lab=w_inv5}
N 8080 -350 8080 -290 {
lab=bit5}
N 7800 0 7850 0 {
lab=OUT_P}
N 8300 0 8380 0 {
lab=OUT_N}
N 8080 80 8080 140 {
lab=GND}
N 8770 -350 8770 -290 {
lab=w_inv5}
N 8820 -350 8820 -290 {
lab=bit5}
N 8540 0 8590 0 {
lab=OUT_P}
N 9040 0 9120 0 {
lab=OUT_N}
N 8820 80 8820 140 {
lab=GND}
N 9480 -350 9480 -290 {
lab=w_inv5}
N 9530 -350 9530 -290 {
lab=bit5}
N 9250 0 9300 0 {
lab=OUT_P}
N 9750 0 9830 0 {
lab=OUT_N}
N 9530 80 9530 140 {
lab=GND}
N 10200 -350 10200 -290 {
lab=w_inv5}
N 10250 -350 10250 -290 {
lab=bit5}
N 9970 0 10020 0 {
lab=OUT_P}
N 10470 0 10550 0 {
lab=OUT_N}
N 10250 80 10250 140 {
lab=GND}
N 10930 -350 10930 -290 {
lab=w_inv5}
N 10980 -350 10980 -290 {
lab=bit5}
N 10700 0 10750 0 {
lab=OUT_P}
N 11200 0 11280 0 {
lab=OUT_N}
N 10980 80 10980 140 {
lab=GND}
N 11670 -350 11670 -290 {
lab=w_inv5}
N 11720 -350 11720 -290 {
lab=bit5}
N 11440 0 11490 0 {
lab=OUT_P}
N 11940 0 12020 0 {
lab=OUT_N}
N 11720 80 11720 140 {
lab=GND}
N 12390 -350 12390 -290 {
lab=w_inv5}
N 12440 -350 12440 -290 {
lab=bit5}
N 12160 0 12210 0 {
lab=OUT_P}
N 12660 0 12740 0 {
lab=OUT_N}
N 12440 80 12440 140 {
lab=GND}
N 13120 -350 13120 -290 {
lab=w_inv5}
N 13170 -350 13170 -290 {
lab=bit5}
N 12890 0 12940 0 {
lab=OUT_P}
N 13390 0 13470 0 {
lab=OUT_N}
N 13170 80 13170 140 {
lab=GND}
N 13830 -350 13830 -290 {
lab=w_inv5}
N 13880 -350 13880 -290 {
lab=bit5}
N 13600 0 13650 0 {
lab=OUT_P}
N 14100 0 14180 0 {
lab=OUT_N}
N 13880 80 13880 140 {
lab=GND}
N 14560 -350 14560 -290 {
lab=w_inv5}
N 14610 -350 14610 -290 {
lab=bit5}
N 14330 0 14380 0 {
lab=OUT_P}
N 14830 0 14910 0 {
lab=OUT_N}
N 14610 80 14610 140 {
lab=GND}
N 15300 -350 15300 -290 {
lab=w_inv5}
N 15350 -350 15350 -290 {
lab=bit5}
N 15070 0 15120 0 {
lab=OUT_P}
N 15570 0 15650 0 {
lab=OUT_N}
N 15350 80 15350 140 {
lab=GND}
N 16030 -350 16030 -290 {
lab=w_inv5}
N 16080 -350 16080 -290 {
lab=bit5}
N 15800 0 15850 0 {
lab=OUT_P}
N 16300 0 16380 0 {
lab=OUT_N}
N 16080 80 16080 140 {
lab=GND}
N 16760 -350 16760 -290 {
lab=w_inv5}
N 16810 -350 16810 -290 {
lab=bit5}
N 16530 0 16580 0 {
lab=OUT_P}
N 17030 0 17110 0 {
lab=OUT_N}
N 16810 80 16810 140 {
lab=GND}
N 17470 -350 17470 -290 {
lab=w_inv5}
N 17520 -350 17520 -290 {
lab=bit5}
N 17240 0 17290 0 {
lab=OUT_P}
N 17740 0 17820 0 {
lab=OUT_N}
N 17520 80 17520 140 {
lab=GND}
N 18200 -350 18200 -290 {
lab=w_inv5}
N 18250 -350 18250 -290 {
lab=bit5}
N 17970 0 18020 0 {
lab=OUT_P}
N 18470 0 18550 0 {
lab=OUT_N}
N 18250 80 18250 140 {
lab=GND}
N 18950 -350 18950 -290 {
lab=w_inv5}
N 19000 -350 19000 -290 {
lab=bit5}
N 18720 0 18770 0 {
lab=OUT_P}
N 19220 0 19300 0 {
lab=OUT_N}
N 19000 80 19000 140 {
lab=GND}
N 19670 -350 19670 -290 {
lab=w_inv5}
N 19720 -350 19720 -290 {
lab=bit5}
N 19440 0 19490 0 {
lab=OUT_P}
N 19940 0 20020 0 {
lab=OUT_N}
N 19720 80 19720 140 {
lab=GND}
N 20390 -350 20390 -290 {
lab=w_inv5}
N 20440 -350 20440 -290 {
lab=bit5}
N 20160 0 20210 0 {
lab=OUT_P}
N 20660 0 20740 0 {
lab=OUT_N}
N 20440 80 20440 140 {
lab=GND}
N 21110 -350 21110 -290 {
lab=w_inv5}
N 21160 -350 21160 -290 {
lab=bit5}
N 20880 0 20930 0 {
lab=OUT_P}
N 21380 0 21460 0 {
lab=OUT_N}
N 21160 80 21160 140 {
lab=GND}
N 21840 -350 21840 -290 {
lab=w_inv5}
N 21890 -350 21890 -290 {
lab=bit5}
N 21610 0 21660 0 {
lab=OUT_P}
N 22110 0 22190 0 {
lab=OUT_N}
N 21890 80 21890 140 {
lab=GND}
N 22560 -350 22560 -290 {
lab=w_inv5}
N 22610 -350 22610 -290 {
lab=bit5}
N 22330 0 22380 0 {
lab=OUT_P}
N 22830 0 22910 0 {
lab=OUT_N}
N 22610 80 22610 140 {
lab=GND}
N 180 -1080 180 -1020 {
lab=w_inv4}
N 230 -1080 230 -1020 {
lab=bit4}
N -50 -730 0 -730 {
lab=OUT_P}
N 450 -730 530 -730 {
lab=OUT_N}
N 230 -650 230 -590 {
lab=GND}
N 900 -1080 900 -1020 {
lab=w_inv4}
N 950 -1080 950 -1020 {
lab=bit4}
N 670 -730 720 -730 {
lab=OUT_P}
N 1170 -730 1250 -730 {
lab=OUT_N}
N 950 -650 950 -590 {
lab=GND}
N 1610 -1080 1610 -1020 {
lab=w_inv4}
N 1660 -1080 1660 -1020 {
lab=bit4}
N 1380 -730 1430 -730 {
lab=OUT_P}
N 1880 -730 1960 -730 {
lab=OUT_N}
N 1660 -650 1660 -590 {
lab=GND}
N 2330 -1080 2330 -1020 {
lab=w_inv4}
N 2380 -1080 2380 -1020 {
lab=bit4}
N 2100 -730 2150 -730 {
lab=OUT_P}
N 2600 -730 2680 -730 {
lab=OUT_N}
N 2380 -650 2380 -590 {
lab=GND}
N 3030 -1080 3030 -1020 {
lab=w_inv4}
N 3080 -1080 3080 -1020 {
lab=bit4}
N 2800 -730 2850 -730 {
lab=OUT_P}
N 3300 -730 3380 -730 {
lab=OUT_N}
N 3080 -650 3080 -590 {
lab=GND}
N 3750 -1080 3750 -1020 {
lab=w_inv4}
N 3800 -1080 3800 -1020 {
lab=bit4}
N 3520 -730 3570 -730 {
lab=OUT_P}
N 4020 -730 4100 -730 {
lab=OUT_N}
N 3800 -650 3800 -590 {
lab=GND}
N 4460 -1080 4460 -1020 {
lab=w_inv4}
N 4510 -1080 4510 -1020 {
lab=bit4}
N 4230 -730 4280 -730 {
lab=OUT_P}
N 4730 -730 4810 -730 {
lab=OUT_N}
N 4510 -650 4510 -590 {
lab=GND}
N 5180 -1080 5180 -1020 {
lab=w_inv4}
N 5230 -1080 5230 -1020 {
lab=bit4}
N 4950 -730 5000 -730 {
lab=OUT_P}
N 5450 -730 5530 -730 {
lab=OUT_N}
N 5230 -650 5230 -590 {
lab=GND}
N 5870 -1080 5870 -1020 {
lab=w_inv4}
N 5920 -1080 5920 -1020 {
lab=bit4}
N 5640 -730 5690 -730 {
lab=OUT_P}
N 6140 -730 6220 -730 {
lab=OUT_N}
N 5920 -650 5920 -590 {
lab=GND}
N 6590 -1080 6590 -1020 {
lab=w_inv4}
N 6640 -1080 6640 -1020 {
lab=bit4}
N 6360 -730 6410 -730 {
lab=OUT_P}
N 6860 -730 6940 -730 {
lab=OUT_N}
N 6640 -650 6640 -590 {
lab=GND}
N 7300 -1080 7300 -1020 {
lab=w_inv4}
N 7350 -1080 7350 -1020 {
lab=bit4}
N 7070 -730 7120 -730 {
lab=OUT_P}
N 7570 -730 7650 -730 {
lab=OUT_N}
N 7350 -650 7350 -590 {
lab=GND}
N 8020 -1080 8020 -1020 {
lab=w_inv4}
N 8070 -1080 8070 -1020 {
lab=bit4}
N 7790 -730 7840 -730 {
lab=OUT_P}
N 8290 -730 8370 -730 {
lab=OUT_N}
N 8070 -650 8070 -590 {
lab=GND}
N 8720 -1080 8720 -1020 {
lab=w_inv4}
N 8770 -1080 8770 -1020 {
lab=bit4}
N 8490 -730 8540 -730 {
lab=OUT_P}
N 8990 -730 9070 -730 {
lab=OUT_N}
N 8770 -650 8770 -590 {
lab=GND}
N 9440 -1080 9440 -1020 {
lab=w_inv4}
N 9490 -1080 9490 -1020 {
lab=bit4}
N 9210 -730 9260 -730 {
lab=OUT_P}
N 9710 -730 9790 -730 {
lab=OUT_N}
N 9490 -650 9490 -590 {
lab=GND}
N 10150 -1080 10150 -1020 {
lab=w_inv4}
N 10200 -1080 10200 -1020 {
lab=bit4}
N 9920 -730 9970 -730 {
lab=OUT_P}
N 10420 -730 10500 -730 {
lab=OUT_N}
N 10200 -650 10200 -590 {
lab=GND}
N 10870 -1080 10870 -1020 {
lab=w_inv4}
N 10920 -1080 10920 -1020 {
lab=bit4}
N 10640 -730 10690 -730 {
lab=OUT_P}
N 11140 -730 11220 -730 {
lab=OUT_N}
N 10920 -650 10920 -590 {
lab=GND}
N 180 -1780 180 -1720 {
lab=w_inv3}
N 230 -1780 230 -1720 {
lab=bit3}
N -50 -1430 0 -1430 {
lab=OUT_P}
N 450 -1430 530 -1430 {
lab=OUT_N}
N 230 -1350 230 -1290 {
lab=GND}
N 890 -1780 890 -1720 {
lab=w_inv3}
N 940 -1780 940 -1720 {
lab=bit3}
N 660 -1430 710 -1430 {
lab=OUT_P}
N 1160 -1430 1240 -1430 {
lab=OUT_N}
N 940 -1350 940 -1290 {
lab=GND}
N 1610 -1780 1610 -1720 {
lab=w_inv3}
N 1660 -1780 1660 -1720 {
lab=bit3}
N 1380 -1430 1430 -1430 {
lab=OUT_P}
N 1880 -1430 1960 -1430 {
lab=OUT_N}
N 1660 -1350 1660 -1290 {
lab=GND}
N 2320 -1780 2320 -1720 {
lab=w_inv3}
N 2370 -1780 2370 -1720 {
lab=bit3}
N 2090 -1430 2140 -1430 {
lab=OUT_P}
N 2590 -1430 2670 -1430 {
lab=OUT_N}
N 2370 -1350 2370 -1290 {
lab=GND}
N 3020 -1780 3020 -1720 {
lab=w_inv3}
N 3070 -1780 3070 -1720 {
lab=bit3}
N 2790 -1430 2840 -1430 {
lab=OUT_P}
N 3290 -1430 3370 -1430 {
lab=OUT_N}
N 3070 -1350 3070 -1290 {
lab=GND}
N 3730 -1780 3730 -1720 {
lab=w_inv3}
N 3780 -1780 3780 -1720 {
lab=bit3}
N 3500 -1430 3550 -1430 {
lab=OUT_P}
N 4000 -1430 4080 -1430 {
lab=OUT_N}
N 3780 -1350 3780 -1290 {
lab=GND}
N 4450 -1780 4450 -1720 {
lab=w_inv3}
N 4500 -1780 4500 -1720 {
lab=bit3}
N 4220 -1430 4270 -1430 {
lab=OUT_P}
N 4720 -1430 4800 -1430 {
lab=OUT_N}
N 4500 -1350 4500 -1290 {
lab=GND}
N 5160 -1780 5160 -1720 {
lab=w_inv3}
N 5210 -1780 5210 -1720 {
lab=bit3}
N 4930 -1430 4980 -1430 {
lab=OUT_P}
N 5430 -1430 5510 -1430 {
lab=OUT_N}
N 5210 -1350 5210 -1290 {
lab=GND}
N 180 -2480 180 -2420 {
lab=w_inv2}
N 230 -2480 230 -2420 {
lab=bit2}
N -50 -2130 0 -2130 {
lab=OUT_P}
N 450 -2130 530 -2130 {
lab=OUT_N}
N 230 -2050 230 -1990 {
lab=GND}
N 880 -2480 880 -2420 {
lab=w_inv2}
N 930 -2480 930 -2420 {
lab=bit2}
N 650 -2130 700 -2130 {
lab=OUT_P}
N 1150 -2130 1230 -2130 {
lab=OUT_N}
N 930 -2050 930 -1990 {
lab=GND}
N 1600 -2480 1600 -2420 {
lab=w_inv2}
N 1650 -2480 1650 -2420 {
lab=bit2}
N 1370 -2130 1420 -2130 {
lab=OUT_P}
N 1870 -2130 1950 -2130 {
lab=OUT_N}
N 1650 -2050 1650 -1990 {
lab=GND}
N 2300 -2480 2300 -2420 {
lab=w_inv2}
N 2350 -2480 2350 -2420 {
lab=bit2}
N 2070 -2130 2120 -2130 {
lab=OUT_P}
N 2570 -2130 2650 -2130 {
lab=OUT_N}
N 2350 -2050 2350 -1990 {
lab=GND}
N 180 -3160 180 -3100 {
lab=w_inv1}
N 230 -3160 230 -3100 {
lab=bit1}
N -50 -2810 0 -2810 {
lab=OUT_P}
N 450 -2810 530 -2810 {
lab=OUT_N}
N 230 -2730 230 -2670 {
lab=GND}
N 880 -3160 880 -3100 {
lab=w_inv1}
N 930 -3160 930 -3100 {
lab=bit1}
N 650 -2810 700 -2810 {
lab=OUT_P}
N 1150 -2810 1230 -2810 {
lab=OUT_N}
N 930 -2730 930 -2670 {
lab=GND}
N 180 -3840 180 -3780 {
lab=w_inv0}
N 230 -3840 230 -3780 {
lab=bit0}
N -50 -3490 0 -3490 {
lab=OUT_P}
N 450 -3490 530 -3490 {
lab=OUT_N}
N 230 -3410 230 -3350 {
lab=GND}
N 210 -4350 210 -4310 {
lab=VDD}
N 210 -4230 210 -4170 {
lab=GND}
N 130 -4270 180 -4270 {
lab=bit0}
N 240 -4270 290 -4270 {
lab=w_inv0}
N 650 -4350 650 -4310 {
lab=VDD}
N 650 -4230 650 -4170 {
lab=GND}
N 570 -4270 620 -4270 {
lab=bit1}
N 680 -4270 730 -4270 {
lab=w_inv1}
N 1070 -4350 1070 -4310 {
lab=VDD}
N 1070 -4230 1070 -4170 {
lab=GND}
N 990 -4270 1040 -4270 {
lab=bit2}
N 1100 -4270 1150 -4270 {
lab=w_inv2}
N 1480 -4360 1480 -4320 {
lab=VDD}
N 1480 -4240 1480 -4180 {
lab=GND}
N 1400 -4280 1450 -4280 {
lab=bit3}
N 1510 -4280 1560 -4280 {
lab=w_inv3}
N 1860 -4360 1860 -4320 {
lab=VDD}
N 1860 -4240 1860 -4180 {
lab=GND}
N 1780 -4280 1830 -4280 {
lab=bit4}
N 1890 -4280 1940 -4280 {
lab=w_inv4}
N 2240 -4360 2240 -4320 {
lab=VDD}
N 2240 -4240 2240 -4180 {
lab=GND}
N 2160 -4280 2210 -4280 {
lab=bit5}
N 2270 -4280 2320 -4280 {
lab=w_inv5}
N 120 -4650 180 -4650 {
lab=VDD}
N 120 -4600 180 -4600 {
lab=VDD}
N 120 -4700 180 -4700 {}
N 120 -4740 180 -4740 {}
N 120 -4780 180 -4780 {}
N 120 -4820 180 -4820 {}
N 120 -4860 180 -4860 {}
N 120 -4900 180 -4900 {}
N 120 -4550 180 -4550 {
lab=VDD}
N 120 -4510 180 -4510 {
lab=VDD}
C {cell_unit.sym} -10 0 0 0 {name=X1}
C {devices/lab_pin.sym} -50 0 0 0 {name=l1 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 530 0 2 0 {name=l2 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 230 140 3 0 {name=l3 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 230 -350 1 0 {name=l4 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 180 -350 1 0 {name=l5 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 710 0 0 0 {name=X2}
C {devices/lab_pin.sym} 670 0 0 0 {name=l6 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 1250 0 2 0 {name=l7 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 950 140 3 0 {name=l8 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 950 -350 1 0 {name=l9 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 900 -350 1 0 {name=l10 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 1420 0 0 0 {name=X3}
C {devices/lab_pin.sym} 1380 0 0 0 {name=l11 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 1960 0 2 0 {name=l12 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 1660 140 3 0 {name=l13 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1660 -350 1 0 {name=l14 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 1610 -350 1 0 {name=l15 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 2130 0 0 0 {name=X4}
C {devices/lab_pin.sym} 2090 0 0 0 {name=l16 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 2670 0 2 0 {name=l17 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 2370 140 3 0 {name=l18 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 2370 -350 1 0 {name=l19 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 2320 -350 1 0 {name=l20 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 2830 0 0 0 {name=X5}
C {devices/lab_pin.sym} 2790 0 0 0 {name=l21 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 3370 0 2 0 {name=l22 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 3070 140 3 0 {name=l23 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 3070 -350 1 0 {name=l24 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 3020 -350 1 0 {name=l25 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 3550 0 0 0 {name=X6}
C {devices/lab_pin.sym} 3510 0 0 0 {name=l26 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 4090 0 2 0 {name=l27 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 3790 140 3 0 {name=l28 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 3790 -350 1 0 {name=l29 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 3740 -350 1 0 {name=l30 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 4260 0 0 0 {name=X7}
C {devices/lab_pin.sym} 4220 0 0 0 {name=l31 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 4800 0 2 0 {name=l32 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 4500 140 3 0 {name=l33 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 4500 -350 1 0 {name=l34 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 4450 -350 1 0 {name=l35 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 4970 0 0 0 {name=X8}
C {devices/lab_pin.sym} 4930 0 0 0 {name=l36 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 5510 0 2 0 {name=l37 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 5210 140 3 0 {name=l38 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 5210 -350 1 0 {name=l39 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 5160 -350 1 0 {name=l40 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 5670 0 0 0 {name=X9}
C {devices/lab_pin.sym} 5630 0 0 0 {name=l41 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 6210 0 2 0 {name=l42 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 5910 140 3 0 {name=l43 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 5910 -350 1 0 {name=l44 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 5860 -350 1 0 {name=l45 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 6390 0 0 0 {name=X10}
C {devices/lab_pin.sym} 6350 0 0 0 {name=l46 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 6930 0 2 0 {name=l47 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 6630 140 3 0 {name=l48 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 6630 -350 1 0 {name=l49 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 6580 -350 1 0 {name=l50 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 7110 0 0 0 {name=X11}
C {devices/lab_pin.sym} 7070 0 0 0 {name=l51 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 7650 0 2 0 {name=l52 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 7350 140 3 0 {name=l53 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 7350 -350 1 0 {name=l54 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 7300 -350 1 0 {name=l55 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 7840 0 0 0 {name=X12}
C {devices/lab_pin.sym} 7800 0 0 0 {name=l56 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 8380 0 2 0 {name=l57 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 8080 140 3 0 {name=l58 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 8080 -350 1 0 {name=l59 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 8030 -350 1 0 {name=l60 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 8580 0 0 0 {name=X13}
C {devices/lab_pin.sym} 8540 0 0 0 {name=l61 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 9120 0 2 0 {name=l62 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 8820 140 3 0 {name=l63 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 8820 -350 1 0 {name=l64 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 8770 -350 1 0 {name=l65 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 9290 0 0 0 {name=X14}
C {devices/lab_pin.sym} 9250 0 0 0 {name=l66 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 9830 0 2 0 {name=l67 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 9530 140 3 0 {name=l68 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 9530 -350 1 0 {name=l69 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 9480 -350 1 0 {name=l70 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 10010 0 0 0 {name=X15}
C {devices/lab_pin.sym} 9970 0 0 0 {name=l71 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 10550 0 2 0 {name=l72 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 10250 140 3 0 {name=l73 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 10250 -350 1 0 {name=l74 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 10200 -350 1 0 {name=l75 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 10740 0 0 0 {name=X16}
C {devices/lab_pin.sym} 10700 0 0 0 {name=l76 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 11280 0 2 0 {name=l77 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 10980 140 3 0 {name=l78 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 10980 -350 1 0 {name=l79 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 10930 -350 1 0 {name=l80 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 11480 0 0 0 {name=X17}
C {devices/lab_pin.sym} 11440 0 0 0 {name=l81 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 12020 0 2 0 {name=l82 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 11720 140 3 0 {name=l83 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 11720 -350 1 0 {name=l84 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 11670 -350 1 0 {name=l85 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 12200 0 0 0 {name=X18}
C {devices/lab_pin.sym} 12160 0 0 0 {name=l86 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 12740 0 2 0 {name=l87 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 12440 140 3 0 {name=l88 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 12440 -350 1 0 {name=l89 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 12390 -350 1 0 {name=l90 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 12930 0 0 0 {name=X19}
C {devices/lab_pin.sym} 12890 0 0 0 {name=l91 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 13470 0 2 0 {name=l92 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 13170 140 3 0 {name=l93 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 13170 -350 1 0 {name=l94 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 13120 -350 1 0 {name=l95 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 13640 0 0 0 {name=X20}
C {devices/lab_pin.sym} 13600 0 0 0 {name=l96 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 14180 0 2 0 {name=l97 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 13880 140 3 0 {name=l98 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 13880 -350 1 0 {name=l99 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 13830 -350 1 0 {name=l100 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 14370 0 0 0 {name=X21}
C {devices/lab_pin.sym} 14330 0 0 0 {name=l101 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 14910 0 2 0 {name=l102 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 14610 140 3 0 {name=l103 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 14610 -350 1 0 {name=l104 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 14560 -350 1 0 {name=l105 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 15110 0 0 0 {name=X22}
C {devices/lab_pin.sym} 15070 0 0 0 {name=l106 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 15650 0 2 0 {name=l107 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 15350 140 3 0 {name=l108 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 15350 -350 1 0 {name=l109 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 15300 -350 1 0 {name=l110 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 15840 0 0 0 {name=X23}
C {devices/lab_pin.sym} 15800 0 0 0 {name=l111 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 16380 0 2 0 {name=l112 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 16080 140 3 0 {name=l113 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 16080 -350 1 0 {name=l114 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 16030 -350 1 0 {name=l115 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 16570 0 0 0 {name=X24}
C {devices/lab_pin.sym} 16530 0 0 0 {name=l116 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 17110 0 2 0 {name=l117 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 16810 140 3 0 {name=l118 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 16810 -350 1 0 {name=l119 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 16760 -350 1 0 {name=l120 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 17280 0 0 0 {name=X25}
C {devices/lab_pin.sym} 17240 0 0 0 {name=l121 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 17820 0 2 0 {name=l122 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 17520 140 3 0 {name=l123 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 17520 -350 1 0 {name=l124 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 17470 -350 1 0 {name=l125 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 18010 0 0 0 {name=X26}
C {devices/lab_pin.sym} 17970 0 0 0 {name=l126 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 18550 0 2 0 {name=l127 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 18250 140 3 0 {name=l128 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 18250 -350 1 0 {name=l129 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 18200 -350 1 0 {name=l130 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 18760 0 0 0 {name=X27}
C {devices/lab_pin.sym} 18720 0 0 0 {name=l131 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 19300 0 2 0 {name=l132 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 19000 140 3 0 {name=l133 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 19000 -350 1 0 {name=l134 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 18950 -350 1 0 {name=l135 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 19480 0 0 0 {name=X28}
C {devices/lab_pin.sym} 19440 0 0 0 {name=l136 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 20020 0 2 0 {name=l137 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 19720 140 3 0 {name=l138 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 19720 -350 1 0 {name=l139 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 19670 -350 1 0 {name=l140 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 20200 0 0 0 {name=X29}
C {devices/lab_pin.sym} 20160 0 0 0 {name=l141 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 20740 0 2 0 {name=l142 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 20440 140 3 0 {name=l143 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 20440 -350 1 0 {name=l144 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 20390 -350 1 0 {name=l145 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 20920 0 0 0 {name=X30}
C {devices/lab_pin.sym} 20880 0 0 0 {name=l146 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 21460 0 2 0 {name=l147 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 21160 140 3 0 {name=l148 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 21160 -350 1 0 {name=l149 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 21110 -350 1 0 {name=l150 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 21650 0 0 0 {name=X31}
C {devices/lab_pin.sym} 21610 0 0 0 {name=l151 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 22190 0 2 0 {name=l152 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 21890 140 3 0 {name=l153 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 21890 -350 1 0 {name=l154 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 21840 -350 1 0 {name=l155 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} 22370 0 0 0 {name=X32}
C {devices/lab_pin.sym} 22330 0 0 0 {name=l156 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 22910 0 2 0 {name=l157 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 22610 140 3 0 {name=l158 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 22610 -350 1 0 {name=l159 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 22560 -350 1 0 {name=l160 sig_type=std_logic lab=w_inv5}
C {cell_unit.sym} -10 -730 0 0 {name=X33}
C {devices/lab_pin.sym} -50 -730 0 0 {name=l161 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 530 -730 2 0 {name=l162 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 230 -590 3 0 {name=l163 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 230 -1080 1 0 {name=l164 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 180 -1080 1 0 {name=l165 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 710 -730 0 0 {name=X34}
C {devices/lab_pin.sym} 670 -730 0 0 {name=l166 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 1250 -730 2 0 {name=l167 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 950 -590 3 0 {name=l168 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 950 -1080 1 0 {name=l169 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 900 -1080 1 0 {name=l170 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 1420 -730 0 0 {name=X35}
C {devices/lab_pin.sym} 1380 -730 0 0 {name=l171 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 1960 -730 2 0 {name=l172 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 1660 -590 3 0 {name=l173 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1660 -1080 1 0 {name=l174 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 1610 -1080 1 0 {name=l175 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 2140 -730 0 0 {name=X36}
C {devices/lab_pin.sym} 2100 -730 0 0 {name=l176 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 2680 -730 2 0 {name=l177 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 2380 -590 3 0 {name=l178 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 2380 -1080 1 0 {name=l179 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 2330 -1080 1 0 {name=l180 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 2840 -730 0 0 {name=X37}
C {devices/lab_pin.sym} 2800 -730 0 0 {name=l181 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 3380 -730 2 0 {name=l182 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 3080 -590 3 0 {name=l183 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 3080 -1080 1 0 {name=l184 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 3030 -1080 1 0 {name=l185 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 3560 -730 0 0 {name=X38}
C {devices/lab_pin.sym} 3520 -730 0 0 {name=l186 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 4100 -730 2 0 {name=l187 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 3800 -590 3 0 {name=l188 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 3800 -1080 1 0 {name=l189 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 3750 -1080 1 0 {name=l190 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 4270 -730 0 0 {name=X39}
C {devices/lab_pin.sym} 4230 -730 0 0 {name=l191 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 4810 -730 2 0 {name=l192 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 4510 -590 3 0 {name=l193 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 4510 -1080 1 0 {name=l194 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 4460 -1080 1 0 {name=l195 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 4990 -730 0 0 {name=X40}
C {devices/lab_pin.sym} 4950 -730 0 0 {name=l196 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 5530 -730 2 0 {name=l197 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 5230 -590 3 0 {name=l198 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 5230 -1080 1 0 {name=l199 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 5180 -1080 1 0 {name=l200 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 5680 -730 0 0 {name=X41}
C {devices/lab_pin.sym} 5640 -730 0 0 {name=l201 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 6220 -730 2 0 {name=l202 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 5920 -590 3 0 {name=l203 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 5920 -1080 1 0 {name=l204 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 5870 -1080 1 0 {name=l205 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 6400 -730 0 0 {name=X42}
C {devices/lab_pin.sym} 6360 -730 0 0 {name=l206 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 6940 -730 2 0 {name=l207 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 6640 -590 3 0 {name=l208 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 6640 -1080 1 0 {name=l209 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 6590 -1080 1 0 {name=l210 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 7110 -730 0 0 {name=X43}
C {devices/lab_pin.sym} 7070 -730 0 0 {name=l211 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 7650 -730 2 0 {name=l212 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 7350 -590 3 0 {name=l213 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 7350 -1080 1 0 {name=l214 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 7300 -1080 1 0 {name=l215 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 7830 -730 0 0 {name=X44}
C {devices/lab_pin.sym} 7790 -730 0 0 {name=l216 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 8370 -730 2 0 {name=l217 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 8070 -590 3 0 {name=l218 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 8070 -1080 1 0 {name=l219 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 8020 -1080 1 0 {name=l220 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 8530 -730 0 0 {name=X45}
C {devices/lab_pin.sym} 8490 -730 0 0 {name=l221 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 9070 -730 2 0 {name=l222 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 8770 -590 3 0 {name=l223 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 8770 -1080 1 0 {name=l224 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 8720 -1080 1 0 {name=l225 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 9250 -730 0 0 {name=X46}
C {devices/lab_pin.sym} 9210 -730 0 0 {name=l226 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 9790 -730 2 0 {name=l227 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 9490 -590 3 0 {name=l228 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 9490 -1080 1 0 {name=l229 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 9440 -1080 1 0 {name=l230 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 9960 -730 0 0 {name=X47}
C {devices/lab_pin.sym} 9920 -730 0 0 {name=l231 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 10500 -730 2 0 {name=l232 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 10200 -590 3 0 {name=l233 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 10200 -1080 1 0 {name=l234 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 10150 -1080 1 0 {name=l235 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} 10680 -730 0 0 {name=X48}
C {devices/lab_pin.sym} 10640 -730 0 0 {name=l236 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 11220 -730 2 0 {name=l237 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 10920 -590 3 0 {name=l238 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 10920 -1080 1 0 {name=l239 sig_type=std_logic lab=bit4
}
C {devices/lab_pin.sym} 10870 -1080 1 0 {name=l240 sig_type=std_logic lab=w_inv4}
C {cell_unit.sym} -10 -1430 0 0 {name=X49}
C {devices/lab_pin.sym} -50 -1430 0 0 {name=l241 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 530 -1430 2 0 {name=l242 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 230 -1290 3 0 {name=l243 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 230 -1780 1 0 {name=l244 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 180 -1780 1 0 {name=l245 sig_type=std_logic lab=w_inv3}
C {cell_unit.sym} 700 -1430 0 0 {name=X50}
C {devices/lab_pin.sym} 660 -1430 0 0 {name=l246 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 1240 -1430 2 0 {name=l247 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 940 -1290 3 0 {name=l248 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 940 -1780 1 0 {name=l249 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 890 -1780 1 0 {name=l250 sig_type=std_logic lab=w_inv3}
C {cell_unit.sym} 1420 -1430 0 0 {name=X51}
C {devices/lab_pin.sym} 1380 -1430 0 0 {name=l251 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 1960 -1430 2 0 {name=l252 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 1660 -1290 3 0 {name=l253 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1660 -1780 1 0 {name=l254 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 1610 -1780 1 0 {name=l255 sig_type=std_logic lab=w_inv3}
C {cell_unit.sym} 2130 -1430 0 0 {name=X52}
C {devices/lab_pin.sym} 2090 -1430 0 0 {name=l256 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 2670 -1430 2 0 {name=l257 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 2370 -1290 3 0 {name=l258 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 2370 -1780 1 0 {name=l259 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 2320 -1780 1 0 {name=l260 sig_type=std_logic lab=w_inv3}
C {cell_unit.sym} 2830 -1430 0 0 {name=X53}
C {devices/lab_pin.sym} 2790 -1430 0 0 {name=l261 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 3370 -1430 2 0 {name=l262 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 3070 -1290 3 0 {name=l263 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 3070 -1780 1 0 {name=l264 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 3020 -1780 1 0 {name=l265 sig_type=std_logic lab=w_inv3}
C {cell_unit.sym} 3540 -1430 0 0 {name=X54}
C {devices/lab_pin.sym} 3500 -1430 0 0 {name=l266 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 4080 -1430 2 0 {name=l267 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 3780 -1290 3 0 {name=l268 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 3780 -1780 1 0 {name=l269 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 3730 -1780 1 0 {name=l270 sig_type=std_logic lab=w_inv3}
C {cell_unit.sym} 4260 -1430 0 0 {name=X55}
C {devices/lab_pin.sym} 4220 -1430 0 0 {name=l271 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 4800 -1430 2 0 {name=l272 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 4500 -1290 3 0 {name=l273 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 4500 -1780 1 0 {name=l274 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 4450 -1780 1 0 {name=l275 sig_type=std_logic lab=w_inv3}
C {cell_unit.sym} 4970 -1430 0 0 {name=X56}
C {devices/lab_pin.sym} 4930 -1430 0 0 {name=l276 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 5510 -1430 2 0 {name=l277 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 5210 -1290 3 0 {name=l278 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 5210 -1780 1 0 {name=l279 sig_type=std_logic lab=bit3
}
C {devices/lab_pin.sym} 5160 -1780 1 0 {name=l280 sig_type=std_logic lab=w_inv3}
C {cell_unit.sym} -10 -2130 0 0 {name=X57}
C {devices/lab_pin.sym} -50 -2130 0 0 {name=l281 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 530 -2130 2 0 {name=l282 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 230 -1990 3 0 {name=l283 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 230 -2480 1 0 {name=l284 sig_type=std_logic lab=bit2
}
C {devices/lab_pin.sym} 180 -2480 1 0 {name=l285 sig_type=std_logic lab=w_inv2}
C {cell_unit.sym} 690 -2130 0 0 {name=X58}
C {devices/lab_pin.sym} 650 -2130 0 0 {name=l286 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 1230 -2130 2 0 {name=l287 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 930 -1990 3 0 {name=l288 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 930 -2480 1 0 {name=l289 sig_type=std_logic lab=bit2
}
C {devices/lab_pin.sym} 880 -2480 1 0 {name=l290 sig_type=std_logic lab=w_inv2}
C {cell_unit.sym} 1410 -2130 0 0 {name=X59}
C {devices/lab_pin.sym} 1370 -2130 0 0 {name=l291 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 1950 -2130 2 0 {name=l292 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 1650 -1990 3 0 {name=l293 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1650 -2480 1 0 {name=l294 sig_type=std_logic lab=bit2
}
C {devices/lab_pin.sym} 1600 -2480 1 0 {name=l295 sig_type=std_logic lab=w_inv2}
C {cell_unit.sym} 2110 -2130 0 0 {name=X60}
C {devices/lab_pin.sym} 2070 -2130 0 0 {name=l296 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 2650 -2130 2 0 {name=l297 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 2350 -1990 3 0 {name=l298 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 2350 -2480 1 0 {name=l299 sig_type=std_logic lab=bit2
}
C {devices/lab_pin.sym} 2300 -2480 1 0 {name=l300 sig_type=std_logic lab=w_inv2}
C {cell_unit.sym} -10 -2810 0 0 {name=X61}
C {devices/lab_pin.sym} -50 -2810 0 0 {name=l301 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 530 -2810 2 0 {name=l302 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 230 -2670 3 0 {name=l303 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 230 -3160 1 0 {name=l304 sig_type=std_logic lab=bit1
}
C {devices/lab_pin.sym} 180 -3160 1 0 {name=l305 sig_type=std_logic lab=w_inv1}
C {cell_unit.sym} 690 -2810 0 0 {name=X62}
C {devices/lab_pin.sym} 650 -2810 0 0 {name=l306 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 1230 -2810 2 0 {name=l307 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 930 -2670 3 0 {name=l308 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 930 -3160 1 0 {name=l309 sig_type=std_logic lab=bit1
}
C {devices/lab_pin.sym} 880 -3160 1 0 {name=l310 sig_type=std_logic lab=w_inv1}
C {cell_unit.sym} -10 -3490 0 0 {name=X63}
C {devices/lab_pin.sym} -50 -3490 0 0 {name=l311 sig_type=std_logic lab=OUT_P}
C {devices/lab_pin.sym} 530 -3490 2 0 {name=l312 sig_type=std_logic lab=OUT_N}
C {devices/lab_pin.sym} 230 -3350 3 0 {name=l313 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 230 -3840 1 0 {name=l314 sig_type=std_logic lab=bit0
}
C {devices/lab_pin.sym} 180 -3840 1 0 {name=l315 sig_type=std_logic lab=w_inv0}
C {inv.sym} 160 -4270 0 0 {name=X64}
C {devices/lab_pin.sym} 210 -4170 3 0 {name=l316 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 210 -4350 1 0 {name=l317 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 130 -4270 0 0 {name=l318 sig_type=std_logic lab=bit0}
C {devices/lab_pin.sym} 290 -4270 2 0 {name=l319 sig_type=std_logic lab=w_inv0}
C {inv.sym} 600 -4270 0 0 {name=X65}
C {devices/lab_pin.sym} 650 -4170 3 0 {name=l320 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 650 -4350 1 0 {name=l321 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 570 -4270 0 0 {name=l322 sig_type=std_logic lab=bit1}
C {devices/lab_pin.sym} 730 -4270 2 0 {name=l323 sig_type=std_logic lab=w_inv1}
C {inv.sym} 1020 -4270 0 0 {name=X66}
C {devices/lab_pin.sym} 1070 -4170 3 0 {name=l324 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1070 -4350 1 0 {name=l325 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 990 -4270 0 0 {name=l326 sig_type=std_logic lab=bit2}
C {devices/lab_pin.sym} 1150 -4270 2 0 {name=l327 sig_type=std_logic lab=w_inv2}
C {inv.sym} 1430 -4280 0 0 {name=X67}
C {devices/lab_pin.sym} 1480 -4180 3 0 {name=l328 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1480 -4360 1 0 {name=l329 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1400 -4280 0 0 {name=l330 sig_type=std_logic lab=bit3}
C {devices/lab_pin.sym} 1560 -4280 2 0 {name=l331 sig_type=std_logic lab=w_inv3}
C {inv.sym} 1810 -4280 0 0 {name=X68}
C {devices/lab_pin.sym} 1860 -4180 3 0 {name=l332 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1860 -4360 1 0 {name=l333 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1780 -4280 0 0 {name=l334 sig_type=std_logic lab=bit4}
C {devices/lab_pin.sym} 1940 -4280 2 0 {name=l335 sig_type=std_logic lab=w_inv4}
C {inv.sym} 2190 -4280 0 0 {name=X69}
C {devices/lab_pin.sym} 2240 -4180 3 0 {name=l336 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 2240 -4360 1 0 {name=l337 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2160 -4280 0 0 {name=l338 sig_type=std_logic lab=bit5}
C {devices/lab_pin.sym} 2320 -4280 2 0 {name=l339 sig_type=std_logic lab=w_inv5}
C {devices/iopin.sym} 130 -4650 2 0 {name=p1 lab=VDD}
C {devices/lab_pin.sym} 180 -4650 2 0 {name=l340 sig_type=std_logic lab=VDD}
C {devices/iopin.sym} 130 -4600 2 0 {name=p2 lab=GND}
C {devices/lab_pin.sym} 180 -4600 2 0 {name=l341 sig_type=std_logic lab=GND}
C {devices/ipin.sym} 130 -4700 0 0 {name=p3 lab=bit0}
C {devices/lab_pin.sym} 180 -4700 2 0 {name=l342 sig_type=std_logic lab=bit0}
C {devices/ipin.sym} 130 -4740 0 0 {name=p4 lab=bit1}
C {devices/lab_pin.sym} 180 -4740 2 0 {name=l343 sig_type=std_logic lab=bit1}
C {devices/ipin.sym} 130 -4780 0 0 {name=p5 lab=bit2}
C {devices/lab_pin.sym} 180 -4780 2 0 {name=l344 sig_type=std_logic lab=bit2}
C {devices/ipin.sym} 130 -4820 0 0 {name=p6 lab=bit3}
C {devices/lab_pin.sym} 180 -4820 2 0 {name=l345 sig_type=std_logic lab=bit3}
C {devices/ipin.sym} 130 -4860 0 0 {name=p7 lab=bit4}
C {devices/lab_pin.sym} 180 -4860 2 0 {name=l346 sig_type=std_logic lab=bit4}
C {devices/ipin.sym} 130 -4900 0 0 {name=p8 lab=bit5}
C {devices/lab_pin.sym} 180 -4900 2 0 {name=l347 sig_type=std_logic lab=bit5}
C {devices/iopin.sym} 130 -4550 2 0 {name=p9 lab=OUT_P}
C {devices/lab_pin.sym} 180 -4550 2 0 {name=l348 sig_type=std_logic lab=OUT_P}
C {devices/iopin.sym} 130 -4510 2 0 {name=p10 lab=OUT_N}
C {devices/lab_pin.sym} 180 -4510 2 0 {name=p11 lab=OUT_N}